HEC-RAS study FRENCHCK.prj: FRENCHCK

--- FRENCHCK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,59124   ,526.1,534.6,516.3
XS GIS Cut Line= 3
2166312.76615367 687710.084550072166451.41343425687535.588744518
2166713.31729653687520.853142084
#Sta/Elev= 30
       0 1460.96    31.8 1459.65    54.3  1459.7   127.6 1461.65   154.4 1460.65
   174.9 1458.81     191 1456.46   204.8 1455.23   222.9 1452.57   243.7 1445.07
   251.7 1441.81   256.2 1440.46   263.7 1439.24   279.7 1439.56   299.8 1439.34
   363.9 1439.79   379.9 1438.97   391.9 1439.22   399.9 1438.16   404.1 1438.15
   407.9 1437.81   415.9 1435.56   429.1 1435.18     436 1435.26  441.28  1438.1
  441.54 1439.17     448 1447.79     456 1453.84     472 1463.29   485.2 1469.56
#Mann= 4 ,-1,0
       0     .05       0     110      .1       0   404.1    .045       0
  441.28      .1       0
Bank Sta=404.1,441.28
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,58589   ,568,543.4,503.6
XS GIS Cut Line= 3
2166270.46299035688009.2377384052166599.68247898687933.773580175
2166737.19671788687899.058088444
#Sta/Elev= 30
       0 1498.71      10 1495.33    26.4 1491.05    42.8 1485.25    63.3 1476.08
    79.7 1466.17    96.1    1459   108.5 1455.12   120.8 1450.35   133.1  1449.7
   137.2 1447.99   141.7 1444.54  147.61 1438.87   149.5 1437.12   153.6 1435.01
   157.7 1434.78   178.2 1435.54   182.3 1437.66   186.4 1438.89   194.6 1438.35
   227.5 1438.39   231.6 1438.73   243.9  1441.9     248 1442.27   284.4 1442.61
   301.3 1443.71     322 1447.19   375.4 1460.89   442.5 1471.95   479.6 1479.07
#Mann= 5 ,-1,0
       0      .1       0      10     .05       0  147.61    .045       0
   186.4     .05       0     210      .1       0
Bank Sta=147.61,186.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,58046   ,407.5,406.4,407.1
XS GIS Cut Line= 3
2166742.50382213688640.4532006212166737.01063443688175.893304037
2166820.49144623688054.949265761
#Sta/Elev= 30
       0 1508.31    31.3 1499.66    79.3 1489.09    91.3 1484.94   103.3 1482.58
   119.3 1477.69   159.3 1467.67   179.3 1460.19   199.3 1458.69   226.9 1451.03
   247.3 1446.88   255.3 1443.57   279.3 1443.12   323.3 1439.38  328.65  1437.7
   335.3 1434.84   351.3 1434.63   355.3 1434.72   363.3 1437.66   367.3 1438.16
   375.3 1436.98   387.3 1438.56   423.3 1438.48   431.3 1440.83   447.3 1447.18
   492.2 1460.71   526.5 1464.71   550.5 1468.52   584.5 1481.94   611.5 1490.86
#Mann= 5 ,-1,0
       0     .05       0     300     .06       0  328.65    .045       0
   363.3     .06       0     400      .1       0
Bank Sta=328.65,363.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,57640   ,512.4,520.4,526.9
XS GIS Cut Line= 4
2167167.96058894688525.2048898682167133.09481541688352.326207337
2167124.51625527   688103.023927 2167087.9101422688001.089867624
#Sta/Elev= 30
       0 1482.04    20.4 1479.47    36.8 1475.79    81.6 1468.35   106.1 1462.55
   126.5 1459.37   142.8 1455.92   155.1 1454.35   159.2 1453.13   167.3 1448.13
   191.5 1447.63   227.5 1442.36   287.6  1437.8   295.6 1436.71326.42311436.973
   335.6 1434.37   339.6 1434.25   355.6 1434.55   363.6 1436.97   373.8 1437.01
   387.6 1441.15   391.6 1442.84   419.7 1458.54   423.7  1459.6   427.8 1459.82
   440.5 1465.05   452.5 1468.34   478.8 1473.43     517 1485.62   534.1    1490
#Mann= 5 ,-1,0
       0     .05       0  186.36     .06       0  286.36      .1       0
326.4231    .045       0   363.6      .1       0
Bank Sta=326.4231,363.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,57119   ,421.3,421,400.1
XS GIS Cut Line= 3
2167485.86559204688529.1203138592167580.06890313 688359.19676877
 2167686.8495243687989.977980357
#Sta/Elev= 30
       0 1494.98    36.5 1488.71    68.5 1484.01    95.5 1477.42   104.6 1473.91
   123.4 1468.24   169.2 1461.05   182.9    1458   200.6 1450.51   208.9 1444.84
     213 1442.59   250.5    1444   271.3 1441.76   317.1 1439.11   358.8 1436.94
   367.2  1437.4   392.1  1436.5   400.4 1434.09   404.6 1434.01   425.4 1434.22
   429.6  1435.3  431.18 1436.48   438.2 1441.51   450.4 1446.51   487.9 1465.69
   502.8 1471.85   512.8 1475.12     542 1480.46   554.5 1483.31   578.6 1491.58
#Mann= 5 ,-1,0
       0     .05       0  214.29     .06       0  314.29      .1       0
   392.1    .045       0  431.18      .1       0
Bank Sta=392.1,431.18
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,56698   ,470.7,442.9,415
XS GIS Cut Line= 3
2168072.13429161688444.4972042312168013.87102669688081.273402699
2167952.65300672687907.480945186
#Sta/Elev= 30
       0 1489.04     7.4 1487.54    15.5 1484.64    51.7 1474.45   114.6 1459.44
     137 1452.95   165.4 1447.17   169.5 1444.56   173.5 1443.23   189.7  1442.5
   205.9 1440.06  215.19 1437.28   222.1 1434.67   226.2 1434.05   246.4 1433.89
   250.5 1433.97   262.6 1437.26   274.8  1437.5   315.3 1440.95   335.6  1440.5
   343.7 1441.97   355.8 1447.35   367.9 1453.71   384.9 1463.81   393.4 1467.07
   406.1 1473.26   427.3 1478.13   450.4 1482.28   529.2 1507.08   552.1 1512.81
#Mann= 5 ,-1,0
       0     .05       0     150     .07       0  215.19    .045       0
   262.6     .07       0     300      .1       0
Bank Sta=215.19,262.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,56255   ,383.3,383.5,381.4
XS GIS Cut Line= 4
2168586.54945295688000.6976018632168451.46801964687969.705226475
2168152.83270973687921.7695578232168026.86197104687835.683595652
#Sta/Elev= 30
       0 1494.56    18.9 1488.63    31.2 1483.06    41.6 1482.42    51.7 1480.09
    80.4 1481.61   100.9 1481.07   109.1 1478.75   133.8 1464.46   137.9 1462.88
   202.7 1448.41   231.1 1446.48   235.1 1445.29   247.3 1439.39   255.4 1440.06
   263.5 1439.51  275.25 1435.71   295.9 1433.71     304 1435.69   328.3 1438.23
   352.6 1438.26   373.6 1441.29     385 1443.95   417.7    1457   441.8  1468.7
   466.1 1478.15   476.5 1479.97     500 1485.98   574.3 1510.71   593.6 1515.97
#Mann= 4 ,-1,0
       0     .07       0  248.59      .1       0  275.25    .045       0
     304      .1       0
Bank Sta=275.25,304
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55872   ,137.8,138.1,138.5
XS GIS Cut Line= 2
2168596.21714761687597.263818873 2168156.7478041687547.346365602
#Sta/Elev= 30
       0 1480.45     8.1 1478.63    21.8  1478.6    28.2 1476.74    56.4 1457.13
    60.4 1454.81    64.5 1453.93    72.5  1454.9   100.7 1455.07   104.7  1454.3
   108.7 1452.14   116.8 1446.05   124.8 1442.47   213.4 1440.53   221.5 1439.16
  225.91 1436.91   233.5 1433.88   237.6 1433.79   257.7 1434.02   265.7 1436.93
   281.8    1437   289.9 1438.45     310 1446.93   338.2 1455.63   402.6 1478.92
   410.7  1480.3   414.7 1482.23   418.7 1483.08   426.8 1482.54442.2952 1484.94
#Mann= 6 ,-1,0
       0     .06       0     160      .1       0  225.91    .045       0
   265.7      .1       0     340     .06       0     360     .05       0
Bank Sta=225.91,265.7
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55734   ,61.5,64.3,59.5
XS GIS Cut Line= 2
2168606.70862176687463.5144073142168150.60012716687404.787991701
#Sta/Elev= 30
       0 1487.57    18.7 1480.37    34.8 1469.46      51 1459.61      63 1451.55
    67.1 1449.77   107.4 1449.43   131.6 1445.96   147.7 1444.76     208 1442.93
   216.3 1441.78  228.041437.098   232.4  1434.7   240.2 1433.89   260.7 1434.01
   268.7 1437.09   268.7  1437.1   272.8 1437.88   287.2 1446.06   292.9 1448.38
   300.9 1449.31   349.4 1451.03   353.4 1451.57   361.6 1454.74   368.8 1456.69
   393.8 1461.73   409.9 1462.02     422 1460.95   438.1  1467.7459.8736 1471.97
#Mann= 6 ,-1,0
       0     .08       0      70     .07       0  228.04    .045       0
   268.7     .07       0     270     .06       0     370     .07       0
Bank Sta=228.04,268.7
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55669   ,148.6,148.7,151.1
XS GIS Cut Line= 2
 2168615.5175841687406.745538888 2168159.4090895687348.019123275
#Sta/Elev= 30
       0 1489.12    15.5  1484.4    19.5 1482.55    27.6 1477.94    55.8  1459.3
    71.9 1449.47      76 1448.03      80 1448.11   108.2 1448.06   132.4 1444.85
     205 1444.08   209.1 1443.04  218.581436.711   221.2 1435.03   225.2 1433.74
   229.2  1434.2   237.3 1437.24   250.9 1435.05  257.281436.711   261.6 1438.34
   269.5 1439.85   281.6 1444.84   338.1  1447.7   386.5 1456.63   402.6 1456.92
   410.7 1454.92   426.8 1456.96   438.9  1456.6     447 1461.36459.8736 1465.37
#Mann= 5 ,-1,0
       0     .08       0      80     .07       0  218.58    .045       0
  257.28     .07       0     280     .06       0
Bank Sta=218.58,257.28
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55521   ,110.4,118.2,121.8
XS GIS Cut Line= 3
2168591.32327964687317.3345711172168532.59686403687250.777966755
2168162.62044566687190.094003955
#Sta/Elev= 30
       0 1472.63    22.9 1464.56    50.5 1449.92    59.2 1446.18    93.2 1446.62
   109.5 1445.42   121.6 1443.06   170.3 1443.91   181.1 1441.65  192.411436.139
   198.6 1433.53   213.4 1433.26   218.9 1434.09  222.21 1436.14     227 1438.91
   275.6 1438.94   291.9  1440.8   308.1 1446.59   323.8 1450.15   337.8 1457.11
   340.5 1457.45   348.2 1455.92   368.9 1456.17   376.1 1459.38   389.1 1469.69
   393.2 1471.67   428.3 1482.94   441.8 1490.24   449.9 1491.46463.6815 1491.39
#Mann= 6 ,-1,0
       0     .08       0  188.76     .05       0  192.41    .045       0
  222.21     .05       0  288.76     .06       0  388.76     .05       0
Bank Sta=192.41,222.21
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55402   ,118.2,145.7,171.3
XS GIS Cut Line= 3
2168591.32327964687288.9501369032168520.85158091687153.879380993
2168193.94120066687028.596361018
#Sta/Elev= 30
       0 1470.24    31.8 1461.74      50 1451.34    58.7 1447.13    64.4  1445.7
      76 1444.67      90  1446.7   111.9 1447.13   152.3 1446.14   187.3 1443.81
   195.9  1442.3     213 1443.49   221.4 1440.55  227.271435.973   230.8 1433.78
   240.1 1433.15   261.8 1433.89  269.051435.971   289.7 1437.71   320.1 1442.06
   341.6 1448.27     363 1456.26   380.1 1463.86   388.8 1464.68   414.4 1463.58
   418.7 1465.88     429  1473.8   435.2 1476.62   484.8 1488.05502.4441 1493.19
#Mann= 5 ,-1,0
       0     .08       0     140     .07       0  227.27    .045       0
  269.05     .06       0  342.35     .05       0
Bank Sta=227.27,269.05
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55257   ,91,89.2,90.8
XS GIS Cut Line= 6
2168589.63767201687270.8047301972168498.01949266687070.441083856
2168487.29824335687018.1724222472168444.53099862686883.457387811
2168387.19654347686812.5188017682168046.02112444686774.244013803
#Sta/Elev= 30
       0 1467.99    26.5 1460.34    32.6 1457.76    45.8 1448.65    56.7  1445.8
   118.9 1447.35   233.9 1445.07   246.1 1442.38   274.7 1438.44  284.741435.874
   296.1 1432.93   320.9 1432.57  338.571435.873   396.4 1446.05   442.5 1450.52
     488 1452.47   505.4 1456.45   533.4 1457.66   562.6 1467.07   601.8 1470.15
     630 1480.29     634  1482.8   642.1 1490.55   646.1 1492.71   662.2 1496.42
   687.2 1504.04   746.2 1516.44   791.5    1531   831.3 1546.94   849.5 1550.91
#Mann= 8 ,-1,0
       0     .08       0     120     .07       0  230.32     .06       0
  284.74    .045       0  338.57     .07       0  425.01     .06       0
  656.23     .05       0  849.54      .1       0
Bank Sta=284.74,338.57
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55168   ,149.3,158.3,162.6
XS GIS Cut Line= 6
2168607.71427706  687260.38744332168560.09781071687186.386041354
2168535.25814943686949.6582706982168492.31425121  686824.4868124
2168434.97979606686753.5482263572168093.80437703686715.273438393
#Sta/Elev= 30
       0  1469.6    27.6 1463.59    48.3 1450.19      57 1446.14    93.2 1446.91
   113.2  1442.7   181.3 1442.09   278.7 1448.89  348.611435.857   355.4 1432.97
     366 1431.84   395.6 1432.12  404.591435.856     421 1442.26   434.1 1445.79
     460 1449.53   485.4 1457.89     551 1460.56   594.1 1458.97   617.2 1459.46
   666.5 1463.11   670.5  1464.5   698.7 1482.22   726.9 1483.17   735.1 1486.77
     743  1492.9     751 1495.89   814.4  1513.3     876 1526.08   894.3 1533.47
#Mann= 7 ,-1,0
       0     .08       0  208.38     .07       0  348.61    .045       0
  404.59     .07       0  417.44     .06       0  650.98      .1       0
  750.98     .05       0
#XS Ineff= 2 , 0
          279.56  1451.1
Permanent Ineff=
       F       F
Bank Sta=348.61,404.59
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55009   ,272.1,301.8,331.2
XS GIS Cut Line= 4
2168615.79261948687247.8416459742168607.96243073687115.707210844
2168642.21950651686743.7732452932168763.58743211686648.832206719
#Sta/Elev= 30
       0 1468.31    10.7 1465.54    34.7 1448.01    38.7 1446.37    90.8 1446.66
   142.2 1445.35   187.1 1442.12   299.6 1438.98   347.8 1435.88     384 1436.68
     404 1438.25   412.1 1437.36  415.06 1435.81   420.1 1433.11   431.4  1431.8
   452.2 1431.95   456.3 1432.53  461.481435.808   468.3 1442.99   472.3 1445.98
   476.3 1447.47     488 1448.48   513.4 1453.21   523.6 1456.93   534.8 1457.61
   543.9  1464.4     549 1466.57   564.2 1469.58   608.8 1484.81659.9653 1500.24
#Mann= 8 ,-1,0
       0     .08       0  182.37     .07       0  282.37     .06       0
  415.06    .045       0  461.48     .06       0  472.37     .08       0
  482.37     .06       0  635.87      .1       0
Bank Sta=415.06,461.48
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54708   ,105,106.4,107.3
XS GIS Cut Line= 4
2168624.84116084687250.2145377062168628.86903571687110.581542192
2168841.00377889687035.3945446072168944.38590057686905.159923791
#Sta/Elev= 30
       0 1469.43      13 1465.45    37.1 1447.94    41.1  1446.2    81.1 1446.23
    97.1 1447.85   113.1 1446.69   125.1 1446.95   185.6 1441.39   262.4 1441.35
   291.7 1440.37   304.5 1439.12  313.911435.647   321.4 1431.78   335.5 1431.66
   342.7 1432.59  347.611435.648   355.4 1442.16   359.6 1444.59   376.3 1446.21
   399.9 1446.65   402.8 1447.82   408.4 1453.65     417 1458.64   439.8 1461.88
   451.2 1468.17   479.6 1479.61   493.9 1481.12   508.1 1489.25531.0356  1494.2
#Mann= 7 ,-1,0
       0     .08       0  159.69      .1       0  259.69     .07       0
  313.91    .045       0  347.61     .07       0  359.69      .1       0
  454.76     .06       0
Bank Sta=313.91,347.61
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54601   ,33.1,33.6,33
XS GIS Cut Line= 5
2168633.12469156687257.959226455 2168637.4062596687188.785372865
2168739.62005564 687177.576456022168884.26104224687134.075407417
2168986.05494487686972.965073968
#Sta/Elev= 30
       0 1471.21    16.8 1467.38    20.8 1465.46    44.9 1446.86    48.9 1445.78
    56.9  1446.3    69.3 1446.23   148.5 1443.26   239.5 1441.22   243.7 1441.01
   247.9 1439.76  254.461435.585   260.4 1432.37   264.6 1431.57   272.4 1431.44
   284.6 1432.33   292.81435.585   318.9 1439.37   367.3 1440.39   395.2 1441.98
   404.7 1443.56   420.4 1448.38   448.4 1461.73   456.7 1464.44   462.9 1467.14
   474.5 1474.16     489 1484.61   491.9 1486.06   497.7 1487.44   513.7 1488.34
#Mann= 8 ,-1,0
       0     .08       0   79.31     .07       0  172.13     .06       0
  222.13     .07       0  254.46    .045       0   292.8     .07       0
  403.17      .1       0  423.17     .06       0
Bank Sta=254.46,292.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54567   ,206.3,172.2,149.8
XS GIS Cut Line= 5
2168643.32079106687259.0019986172168645.74953666687216.949169156
2168760.04695731687205.7402523112168904.68794391687162.239203709
2169006.48184654 687001.12887026
#Sta/Elev= 30
       0 1471.07    17.9 1466.92    21.9 1465.21    25.9 1462.49    42.1  1448.7
    68.7 1445.24    88.1 1443.41    95.4 1444.22   104.8 1444.58   124.7  1444.3
     203 1440.21     225 1437.15  230.821435.556   237.8 1432.71   240.6 1431.98
   244.2 1431.85   257.3 1431.85   261.5 1432.22  269.491435.557   286.6 1439.05
   290.8 1439.39   351.9 1439.28   389.4  1441.3   403.9 1441.56   408.6 1442.22
   422.8 1447.55   449.3 1460.98     465 1467.49   491.1 1479.79   498.6 1482.76
#Mann= 6 ,-1,0
       0     .07       0  142.12     .06       0  230.82    .045       0
  269.49      .1       0  296.97     .07       0  428.01     .06       0
Bank Sta=230.82,269.49
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54395   ,335.1,333,334
XS GIS Cut Line= 3
2168944.38590057 687419.385282272168998.09089884687068.960168529
2169024.94339798686999.143670772
#Sta/Elev= 30
       0 1485.95    10.3 1480.47    18.4 1478.55    30.6 1476.87    46.7 1471.18
    57.9 1465.75      71 1460.92    75.1 1458.09    79.4  1453.9    91.3 1440.43
    95.3 1437.39  102.471435.457   107.4 1433.16   111.5    1432   135.8 1431.78
   139.8 1432.32  145.13 1435.46   147.9 1437.26     152 1437.84   176.2 1436.86
   204.6 1438.39   261.2 1437.75   317.9 1439.38   328.1 1440.19   334.1 1442.08
   354.3 1452.69   383.8 1465.94   402.4 1472.72     421 1480.69 429.319 1483.68
#Mann= 5 ,-1,0
       0      .1       0  102.47    .045       0  145.13      .1       0
     260     .07       0  364.52     .06       0
Bank Sta=102.47,145.13
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54062   ,478.2,485,485.6
XS GIS Cut Line= 3
2169254.58648926 687540.796545432169301.57207809687133.162075041
2169293.43005017686902.188329696
#Sta/Elev= 30
       0 1509.42    19.7 1509.36    39.9 1506.05    88.2 1489.79   120.4 1477.77
   168.7 1453.61   192.9 1443.23     209  1438.6   241.41435.317   249.3  1431.7
   257.2 1431.47   281.5 1431.91  291.121435.317   293.5  1436.4   305.6 1437.13
   321.7 1439.94     362 1440.37     380 1444.04   394.2 1447.01   411.7 1448.73
   446.5 1448.32   450.4 1450.14   458.3 1457.57   466.9 1460.42   518.4 1473.71
   542.4 1476.11   550.4 1480.87   562.4 1484.29   593.4 1489.28   641.5 1499.29
#Mann= 6 ,-1,0
       0     .05       0      90      .1       0   241.4    .045       0
  291.12      .1       0     380     .06       0  480.33      .1       0
Bank Sta=241.4,291.12
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,53577   ,847.6,838.1,812.2
XS GIS Cut Line= 4
2169314.16565063 687544.798087792169671.01464891 687430.29782787
2169825.61316911687062.3434499192169819.96389847686884.400361447
#Sta/Elev= 30
       0 1504.28    18.9 1502.15    39.9 1503.01    64.2 1497.07   102.9 1490.41
   178.5  1482.8   195.5 1482.62   208.2 1481.14   273.7 1470.09     348 1460.24
   393.3 1451.34   445.4 1436.85   488.8 1436.45   510.5 1432.74   523.5 1433.66
   527.8 1431.85   541.5 1431.48   549.5  1431.5  556.14  1433.6   565.9 1436.54
   617.9 1434.79   666.9 1438.19   692.7 1438.81   727.8 1444.81   819.1 1453.31
   879.1 1462.95   919.1 1472.82   931.1 1471.69   947.1 1472.06   951.9 1475.82
#Mann= 4 ,-1,0
       0     .05       0  454.77      .1       0   523.5    .045       0
  556.14      .1       0
Bank Sta=523.5,556.14
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52739   ,408.9,428.8,432.5
XS GIS Cut Line= 4
2170424.79922714687933.6054371592170301.63135454687732.635598937
2170165.74482484687348.770107383 2170155.2343649687162.698466423
#Sta/Elev= 30
       0 1513.05    99.7  1498.1   154.3 1482.39   188.2  1474.5   213.1 1465.62
   260.6 1443.74   277.2 1434.48   280.3 1433.64   324.2 1433.13   364.9  1434.9
   379.4 1433.84   409.1 1434.09   446.4 1435.68     484 1434.43   491.8 1431.46
   509.1 1431.01   519.4 1431.78  526.06 1434.42   574.6  1436.2   595.8 1434.99
   608.5 1436.42   628.2 1443.36   659.2 1456.24   678.1 1465.43   698.6 1473.93
   710.6  1477.3   734.7 1481.91   788.1 1502.01   806.4 1507.56   829.3 1512.96
#Mann= 3 ,-1,0
       0      .1       0     484    .045       0  526.06      .1       0
Bank Sta=484,526.06
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52310   ,407.3,442.4,464.3
XS GIS Cut Line= 4
2170519.46585196687809.6501979432170569.32785023687590.827635103
2170610.30286612687326.3930247692170612.20707399687107.655607564
#Sta/Elev= 30
       0    1513    16.9  1511.6    34.4 1508.69    45.6 1505.22    74.3  1492.6
    86.6 1488.49   135.9 1480.75   184.8 1467.56   218.2 1455.48   262.5 1432.99
   278.7 1431.23     303  1432.8   331.3 1432.81     388 1435.08   392.1 1434.98
   396.1 1433.48   400.2 1431.11   412.3 1430.58   428.1 1430.86  436.74 1433.51
   448.7 1439.67   456.2 1442.06   505.2 1451.97   533.2 1455.89   545.2 1458.43
   577.2 1470.08   613.2 1481.47     677 1495.33   697.2 1501.19   710.8  1506.5
#Mann= 3 ,-1,0
       0      .1       0   396.1    .045       0  436.74      .1       0
Bank Sta=396.1,436.74
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,51868   ,570.8,571.1,569.8
XS GIS Cut Line= 3
2170600.36390876687820.5966712682170955.11432356687737.793994824
2171234.68054904687750.382072262
#Sta/Elev= 30
       0 1509.51    16.2 1504.14      46 1491.39    61.4  1486.3    86.1 1479.42
    90.2 1477.03    98.4 1470.54   110.7  1459.6   127.1  1442.8   135.9 1436.55
   139.2 1434.81   143.6 1433.62     160 1432.18   164.1 1430.88   176.4 1430.28
     197 1430.59  199.84 1431.97   205.2 1434.53   209.3 1435.13   250.4 1436.11
   279.1 1435.97   295.5 1437.15   331.8 1442.29   369.4 1449.27   429.4 1462.12
     496 1480.23   557.5 1495.27   581.6 1502.67   625.6 1518.94   644.1 1525.18
#Mann= 3 ,-1,0
       0      .1       0     160    .045       0  199.84      .1       0
Bank Sta=160,199.84
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,51297   ,597.6,586.3,558.1
XS GIS Cut Line= 3
2170578.83974905688266.808632549 2170810.2121272 688352.44387211
2171262.24687453688223.694119608
#Sta/Elev= 30
       0 1513.05    14.2 1513.76    56.9  1509.8    78.2 1506.84   108.7 1498.53
   116.6 1498.53     155 1488.52   193.4 1476.72   231.7 1467.45   248.8 1460.23
   289.8 1439.14   298.7    1436   318.9 1433.26   340.3 1434.18   346.2    1432
   351.3 1430.21   357.8    1430   381.8 1430.17   390.1 1432.04   390.1 1432.06
   419.3  1432.5   435.9 1437.67   469.2 1439.89   502.5 1444.98   531.6 1452.33
     544 1454.24     569 1461.38   585.6 1466.33   618.9 1478.82   716.7 1500.64
#Mann= 4 ,-1,0
       0     .05       0      40      .1       0   346.2    .045       0
   390.1      .1       0
Bank Sta=346.2,390.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50711   ,574.1,551.2,533
XS GIS Cut Line= 3
2171022.27868304688957.8895015532171194.36591262688842.993721817
2171486.85687384688453.828773525
#Sta/Elev= 30
       0 1533.42    10.5 1532.65    16.3 1530.75      25 1525.69    50.4 1508.66
    66.1  1501.2    99.9 1486.78   122.5 1479.77   141.8 1475.55     161 1470.01
   195.8 1456.48   220.9 1445.81   243.2 1438.47  252.97    1433   255.2 1431.53
   259.2 1430.31   286.6 1430.03   292.4  1430.3   300.9 1432.97   329.3  1433.4
   344.3  1432.8   374.3 1433.94   429.4 1439.73   455.2 1444.39   564.5 1461.13
     578 1465.54   649.4 1484.65   666.6 1487.46   684.5 1492.51   693.7 1493.98
#Mann= 5 ,-1,0
       0     .06       0      40     .07       0     100      .1       0
  252.97    .045       0   300.9      .1       0
Bank Sta=252.97,300.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50159   ,537.7,553.9,564.3
XS GIS Cut Line= 4
2171707.25729199689278.7636467662171746.47097996689031.503180849
2171713.24740571688729.7766553972171768.91351749688592.058267552
#Sta/Elev= 30
       0 1536.43      30 1534.39    50.2 1531.16    66.4 1526.78    94.8 1513.92
   145.5 1488.75   178.9 1477.15   208.2  1465.2   216.3 1460.78   224.4 1455.13
   239.9 1450.63   248.7 1449.51   252.7 1448.16   264.8 1441.83  273.81 1433.19
   276.8 1430.65   280.9 1430.05     305 1429.79     309  1430.1   319.8 1433.23
   377.8 1431.29     470 1431.94   506.2 1439.85   522.8 1441.29   554.5 1445.96
   589.1 1452.42   597.7 1456.03   605.8 1458.21   664.1 1481.48   702.4 1491.08
#Mann= 3 ,-1,0
       0      .1       0  273.81    .045       0   319.8      .1       0
Bank Sta=273.81,319.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,49606   ,282.3,277.5,279
XS GIS Cut Line= 3
2172077.07644234689438.6457745192172125.10758003689215.426907033
2172324.49172464688752.561622118
#Sta/Elev= 30
       0 1513.85    38.3 1499.58    46.5 1495.04    54.7 1488.11    58.8 1486.65
   128.3 1483.94   144.7  1476.5   205.9 1458.25   219.3 1451.37   278.7 1437.53
   313.5 1435.96   396.3  1435.9   435.5 1434.19   452.9 1431.07     466 1435.44
   470.3 1435.45     479 1431.59   487.7 1430.16   496.5 1430.02   509.1 1432.84
     552 1431.34   561.1 1429.84  590.31 1431.27   609.8 1452.88   627.1 1463.73
   640.2 1468.39   649.4 1474.26   666.3 1481.98   679.9 1484.02   732.3 1503.53
#Mann= 10 ,-1,0
       0      .1       0      40     .06       0     120      .1       0
  378.33     .07       0  428.33     .08       0  538.33      .1       0
     552    .045       0  590.31      .1       0  628.33     .08       0
  648.33      .1       0
Bank Sta=552,590.31
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,49328   ,635.9,605.7,572.7
XS GIS Cut Line= 4
2172723.42834247689543.3231049762172466.40790703689104.916578301
2172530.36088469688965.8898097082172559.85923577688748.590075713
#Sta/Elev= 30
       0 1533.44      21 1529.39    48.9 1520.63   100.4 1497.96   146.2 1482.93
   178.7 1470.26   196.9  1462.2   205.6 1455.85   220.4  1455.3     225 1453.76
   243.6    1443   266.8 1440.74   285.3 1434.59   378.1 1432.03   498.6 1433.54
   507.9  1433.3  514.82 1431.43   569.5 1429.53   578.4 1431.43   600.4  1432.7
   609.2 1435.74   631.2  1439.3   706.1 1464.94   738.6 1480.35   752.3 1482.68
   762.9 1487.65   799.2 1497.82   816.3 1505.34   867.8 1539.54   880.5 1543.56
#Mann= 8 ,-1,0
       0      .1       0     100     .06       0     300     .08       0
     480     .07       0  514.82    .045       0   578.4     .07       0
  588.19     .08       0  691.22      .1       0
Bank Sta=514.82,578.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,48722   ,534.3,512.4,494.6
XS GIS Cut Line= 2
2173177.54660411689323.1005232242172789.29111015688771.791135965
#Sta/Elev= 30
       0 1498.69      11 1497.28    25.3 1494.01    56.9 1481.77   131.5 1456.31
   144.2 1452.58   163.1 1449.13   169.1 1444.44   173.6 1442.25   193.2 1440.92
   197.6 1437.82   203.3 1430.92   207.8 1429.92   227.4 1429.54   251.9 1430.83
   260.7 1430.98   286.1 1434.24   320.4  1435.9   374.2 1433.47   403.5 1435.14
   413.3 1439.36   426.1 1442.71   435.8  1448.8   487.5 1473.72   523.4 1486.44
   558.1 1489.46   628.2 1500.41     653 1506.16   662.6 1510.07   674.3 1512.89
#Mann= 4 ,-1,0
       0      .1       0     200     .06       0   203.3    .045       0
   251.9      .1       0
Bank Sta=203.3,251.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,48210   ,517.4,535.2,535.9
XS GIS Cut Line= 2
2173538.17199137688752.0615490372172888.25069363 688600.57852495
#Sta/Elev= 30
       0 1507.71    30.8 1499.34    84.2 1488.29   110.7 1479.69   121.2 1473.84
   137.6 1471.34   158.1 1463.19   183.9 1454.52   207.2 1448.41   223.9 1445.39
   232.1 1440.87   236.2 1439.57   248.5 1439.08   252.6 1437.62   260.5 1431.23
   264.9 1429.88   289.6  1429.4   297.8  1429.7     306 1431.29   338.8 1433.08
   388.1 1432.89   403.8 1434.62   433.3 1448.02   474.4  1470.8   494.9 1480.35
   507.2 1484.19   519.6 1486.09   618.1 1516.61   642.8 1522.54   667.3  1524.7
#Mann= 5 ,-1,0
       0      .1       0      80     .06       0     180      .1       0
   260.5    .045       0     306      .1       0
Bank Sta=260.5,306
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,47675   ,461.3,471.2,477.4
XS GIS Cut Line= 3
 2173816.3461136688418.841493961 2173454.9861136688226.203493961
 2173093.6271136688033.565493961
#Sta/Elev= 30
       0 1510.67    13.8 1511.29    22.9 1515.92    45.5 1519.16   140.7  1517.3
   172.8 1513.12   223.1 1495.94   252.7  1489.3   267.5 1484.03   281.2 1477.25
   335.6 1443.45   353.2  1434.1   377.7 1431.07   399.1 1431.84   406.4 1430.13
   421.8 1427.52   444.4 1427.34   459.6 1430.16   485.2 1435.43   509.9 1437.63
   539.5 1446.83   639.3 1486.71   689.2 1498.63   707.3 1504.59   716.4 1505.66
   761.2 1521.52   766.3 1523.52   793.4 1541.29   811.5 1545.63     819  1548.7
#Mann= 7 ,-1,0
       0     .06       0      70     .05       0     160      .1       0
     300     .06       0     370      .1       0   406.4    .045       0
   459.6      .1       0
Bank Sta=406.4,459.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,47204   ,448.2,451.2,450.2
XS GIS Cut Line= 3
2174041.92252495688079.2751118782173813.52963165 687962.21383132
2173462.73932695687627.740269367
#Sta/Elev= 30
       0 1533.29    24.4 1526.46    73.9 1515.75    83.1 1512.17   100.8 1498.92
   150.3 1497.47   184.1 1485.63   199.7 1483.16   217.7 1474.36   222.8    1470
   231.2 1460.17   234.6 1458.43   249.5 1460.27   269.7 1449.43     281 1447.55
   306.4  1438.2   368.7 1433.31   445.1 1433.52   470.5 1429.93   485.1 1427.38
   512.8 1427.79  519.49 1429.83   535.6 1445.67     548 1454.85   573.5 1464.14
   584.6 1465.13   594.3 1469.86   640.7 1486.83   695.1 1501.78   741.3 1519.53
#Mann= 5 ,-1,0
       0      .1       0     100     .06       0  276.65      .1       0
   470.5    .045       0  519.49      .1       0
Bank Sta=470.5,519.49
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,46752   ,451.3,457,449.3
XS GIS Cut Line= 4
2174104.20646815687831.6617297952174093.77305668687621.773047336
2173897.87427021687426.8793167232173616.68938208687401.256779695
#Sta/Elev= 30
       0 1483.42    18.5 1476.59    50.5 1466.67   130.6  1450.5   214.5 1442.65
   231.5 1440.16   267.7 1436.92   325.2 1430.41   355.9 1429.79   364.4 1427.46
   370.4 1427.27   392.5 1427.63  396.62 1429.85   404.2 1432.03   420.8 1432.54
   426.7    1434   440.8 1441.81   486.5 1471.29     508  1481.8   528.4 1490.06
   536.4 1494.51   552.5 1495.29   560.5 1499.47   572.5 1502.73   612.7 1511.99
   636.7 1518.51   681.5 1527.75   698.6 1530.21   725.1 1531.59   768.8 1535.86
#Mann= 5 ,-1,0
       0      .1       0      80     .05       0  270.15      .1       0
   355.9    .045       0  396.62      .1       0
Bank Sta=355.9,396.62
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,46295   ,613,630.5,642.5
XS GIS Cut Line= 3
2174517.89194492687402.503586928 2174173.9955284687089.802506039
2174144.47932356686831.464313272
#Sta/Elev= 30
       0 1501.04    58.8 1490.55    84.3 1484.57   121.3 1470.28   148.3 1458.33
   186.3 1446.29   220.2 1433.86   233.9 1431.91   268.3 1430.46   294.3 1431.13
     308 1428.79   321.3 1426.87   339.1 1427.08   346.8 1428.88   361.8  1431.2
   424.1 1431.19   434.8 1432.82     442 1435.29   459.8 1445.54   477.9 1451.39
   517.8 1474.82   532.1 1477.52   541.9 1482.47   566.1 1488.63   574.1 1492.88
   598.3 1494.06   650.6 1503.76   682.8 1514.05   708.9 1525.19   724.8 1533.09
#Mann= 3 ,-1,0
       0      .1       0     308    .045       0   346.8      .1       0
Bank Sta=308,346.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45665   ,568.2,597.2,628.1
XS GIS Cut Line= 3
2174910.06397074687239.1554457862174806.11219794686992.653772793
2174721.08311705686583.731550763
#Sta/Elev= 30
       0 1553.87    24.3 1547.52    62.9 1534.27    97.6 1520.94   106.3 1515.81
   132.4 1505.16   184.5 1490.87   206.2  1483.1   258.3 1455.08     267 1451.12
   287.4  1439.1   303.8 1431.56     316 1429.25   328.3 1428.73   381.4 1431.33
   418.2 1429.43   426.3 1426.74   441.2 1426.38   454.9 1426.71  462.29 1429.33
   471.3 1436.93   487.6 1443.25   516.2 1449.97   524.4 1453.06   536.6 1453.91
   544.8 1457.15   593.8 1467.27   638.8 1480.86   679.6 1495.73   685.2 1496.93
#Mann= 3 ,-1,0
       0      .1       0   418.2    .045       0  462.29      .1       0
Bank Sta=418.2,462.29
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45068   ,504.9,491.2,482.4
XS GIS Cut Line= 2
2174969.43949914687230.4895301262175514.64937863686875.476500863
#Sta/Elev= 30
       0 1544.56    31.9 1530.83    72.3 1511.99   101.2 1501.27   127.2 1489.28
   134.4 1487.12   178.3 1460.27   218.1 1439.51   241.9 1433.66     266 1432.56
     292 1428.33   323.1 1428.23   342.2 1430.14   361.4 1430.06   368.9 1429.19
   378.7 1425.92   394.7 1425.67   401.9 1426.58  406.26 1429.09   413.8 1437.19
   419.2 1441.64     429 1446.69   468.4 1458.65   508.8 1468.05   533.1  1474.6
   560.9 1485.51   574.2 1486.96   581.5 1491.38   623.8 1506.58   650.6  1513.6
#Mann= 3 ,-1,0
       0      .1       0   368.9    .045       0  406.26      .1       0
Bank Sta=368.9,406.26
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,44577   ,643.3,645.1,637.7
XS GIS Cut Line= 2
2175430.54232701687645.6517246192175702.49460411687038.381012078
#Sta/Elev= 30
       0 1547.73    53.1 1520.95    92.6 1504.02   101.3  1498.8   110.1 1496.19
   128.7 1486.01     159  1467.5   180.2 1451.78     189 1446.24   206.5 1429.46
   209.5 1427.42   215.3 1425.46   228.6 1425.18   234.7 1425.46   241.6 1427.37
   254.7 1429.85   307.3  1428.5   320.5 1432.44   329.2 1434.02   425.4 1432.49
   451.9 1435.43   473.9 1441.94   500.2 1453.67   530.8 1470.56   552.1  1480.4
   570.3 1490.47   592.2 1500.02   605.3 1504.35   644.8 1513.53   665.4 1520.28
#Mann= 3 ,-1,0
       0      .1       0   209.5    .045       0   241.6      .1       0
Bank Sta=209.5,241.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,43931   ,563,569.6,575
XS GIS Cut Line= 3
2175889.39306543687800.1162805582176076.81158693687747.860602388
2176202.41758348 687092.76969363
#Sta/Elev= 30
       0 1557.83    11.2 1555.02    40.3 1538.28     115 1517.94   135.8 1513.14
   205.4 1503.54   221.7 1499.63     251 1484.95   298.8 1453.31   331.7 1436.98
   376.5 1429.88   417.2    1430   449.8 1427.17     458 1424.81   465.8 1424.66
   490.5 1424.82  498.46 1427.17   506.8 1429.77   543.5 1427.65   559.8 1434.63
   608.7 1447.24     629 1454.17   645.3 1462.58   661.6 1473.46   673.8 1478.54
     686 1487.57   714.6 1503.65   783.8 1527.61   836.7 1553.78   861.6 1563.74
#Mann= 5 ,-1,0
       0      .1       0      40     .05       0     140      .1       0
   449.8    .045       0  498.46      .1       0
Bank Sta=449.8,498.46
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,43362   ,506.8,496.9,475.3
XS GIS Cut Line= 4
2176110.49028401688300.6097366282176283.52867277688050.752055236
2176457.03124612687927.9437073642176746.78442853687434.149960384
#Sta/Elev= 30
       0 1499.46   101.4 1490.22   171.6 1475.88   241.8  1459.7   279.6 1452.46
   311.3 1448.82   348.8 1445.99   451.7 1443.35   476.2 1443.88   486.7  1441.9
   552.2  1439.1   641.3 1436.97   686.7 1434.06   705.2 1429.28   716.6 1428.02
   802.6 1427.07   830.6 1429.19   859.9 1427.39   897.8 1429.06   937.1 1426.67
   944.6 1424.67   960.3 1424.41   965.1  1425.1  967.58 1426.64   973.8 1429.17
   994.3 1433.21  1014.8 1442.73  1029.9  1451.6  1061.5 1473.71    1089 1489.87
#Mann= 6 ,-1,0
       0      .1       0      20     .05       0  716.49      .1       0
  826.49     .05       0   937.1    .045       0  967.58      .1       0
Bank Sta=937.1,967.58
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,42865   ,580.5,608.6,619.6
XS GIS Cut Line= 4
2177160.03100166688292.1106815522177099.54628545688202.916217013
2176954.84834592687794.3119621092176860.44349051 687428.85287777
#Sta/Elev= 30
       0 1509.78    32.5 1494.85    80.9 1465.55    85.7 1461.01      97 1447.32
   100.2 1446.07   118.1 1445.08   122.3 1442.82   133.7 1432.77   143.1 1429.26
   211.5 1426.29   321.6 1428.19   393.9 1426.32   423.6 1428.82  432.05 1426.83
   436.4 1424.49   440.6  1424.2   453.4 1424.73   461.8 1426.82   478.8 1427.11
     500 1429.66   554.8 1452.72   571.3 1458.58   608.5 1468.65   691.1 1479.98
   747.9 1485.33   806.8 1495.49   856.4 1507.73   885.8 1512.51   918.7 1515.38
#Mann= 6 ,-1,0
       0      .1       0      60     .06       0  167.77     .05       0
  432.05    .045       0   461.8     .05       0  581.24      .1       0
Bank Sta=432.05,461.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,42256   ,369.9,368.7,356.2
XS GIS Cut Line= 3
2177313.38210511688211.5353736632177275.36073766 688087.15461702
2177618.48923059687495.329118918
#Sta/Elev= 30
       0  1499.3    19.2    1493    86.2  1465.7     107 1454.97   118.2 1443.86
   123.8 1441.24   164.7 1439.87   195.5  1430.9   206.3 1429.05   275.7  1426.6
   280.3 1424.34   284.9 1423.87   303.4 1424.12   316.5  1426.6   339.9 1428.03
   369.2 1426.87   398.4 1428.16   477.5 1427.65     498 1426.63   547.7 1427.72
   588.7 1426.26   627.1 1426.82   653.1 1429.93   659.4 1431.47   676.5 1438.28
   687.2 1447.07   689.9 1448.19   714.5 1449.52   724.2 1459.39   814.2 1513.67
#Mann= 10 ,-1,0
       0      .1       0      50     .06       0      70     .05       0
  180.06     .06       0   275.7    .045       0   316.5     .05       0
  380.06     .06       0  400.06     .05       0  750.06      .1       0
  770.06     .08       0
Bank Sta=275.7,316.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41888   ,81.8,80.7,74.3
XS GIS Cut Line= 6
2177374.26671861688215.0364317682177465.36235661688039.392254656
2177592.97146276687868.4676054282177662.56226526687810.328453971
2177669.39376315687618.3973057092177701.35158993687513.128207673
#Sta/Elev= 30
       0 1498.38    56.3 1483.38   127.4 1458.14   146.3 1452.52   157.1 1447.91
   177.7 1443.18   205.6 1441.78   235.7 1437.96   300.5 1435.54   330.4 1431.66
   380.3 1431.24   411.2 1428.86   451.5 1427.56   502.1 1427.49   520.9 1425.72
     540 1423.51     556  1424.7     572 1423.98  577.19  1425.7     636 1440.15
     672  1442.8     676 1445.62     688 1457.83     692  1460.4   725.3 1478.45
     742 1489.27   754.6 1494.88   762.9 1500.89   783.8 1513.04   804.8 1519.62
#Mann= 8 ,-1,0
       0      .1       0      80     .05       0  257.86     .06       0
  421.17     .07       0   520.9    .045       0  577.19      .1       0
  764.75     .08       0  784.75      .1       0
Bank Sta=520.9,577.19
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41807   ,152.7,157.4,159.5
XS GIS Cut Line= 6
2177407.55775064688245.762534095 2177666.5412435687895.165832884
  2177736.132046687837.0266814272177742.45375648687810.923331962
2177742.96354389687645.0955331652177774.92137067 687539.82643513
#Sta/Elev= 30
       0 1499.81    40.5 1490.51    88.6 1475.88   120.1    1465   149.6 1452.31
   174.8 1445.36   255.4 1442.42   315.5 1433.81   355.5  1430.1   398.6 1431.48
   418.4 1428.41   443.3 1429.66   459.2 1427.74   484.3 1427.41   551.3 1428.13
   579.4  1430.5   587.4 1429.24     597 1425.88   603.4  1424.3   627.4 1423.52
   631.4 1423.87  636.17 1425.91   655.4 1437.44   691.4 1439.08   699.4 1440.79
   716.6 1455.26   740.3 1471.39   773.7 1492.03   803.7 1507.34   829.5 1517.12
#Mann= 11 ,-1,0
       0      .1       0     120     .05       0     250     .06       0
     320     .05       0     370     .07       0  472.73     .05       0
  510.62     .08       0     597    .045       0  636.17      .1       0
  713.64     .07       0  809.46      .1       0
Bank Sta=597,636.17
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41649   ,445.9,460.6,451.3
XS GIS Cut Line= 4
2177914.29241652688259.0748055082177852.20235138688096.732012844
2177903.69772718687716.4581696442177874.98425728687515.460556284
#Sta/Elev= 30
       0 1471.55    79.1 1451.54   134.8 1446.94   189.5 1440.66   209.7 1437.19
   257.4 1434.46   283.6 1430.97   298.5 1426.56   415.6 1425.78   439.8 1427.65
   480.1  1427.4   488.2  1424.1   492.2 1423.59   514.7 1423.91   516.5 1424.17
   520.8 1427.33   524.5 1431.24   528.6  1433.8   540.7  1435.1   550.2 1443.14
   556.8    1446   605.3 1449.94   609.4 1452.48   617.4 1462.56   621.5 1465.23
   637.6  1474.3   645.7 1476.34     674 1491.29   722.5 1510.36   760.6 1521.36
#Mann= 11 ,-1,0
       0     .05       0  223.81     .06       0  323.81     .05       0
  423.81     .07       0  463.81     .05       0   480.1    .045       0
   520.8     .05       0  523.81     .08       0  617.56      .1       0
  657.56     .08       0  717.56      .1       0
Bank Sta=480.1,520.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41189   ,579.6,592.3,600.9
XS GIS Cut Line= 4
2178226.66965568688256.9517520752178237.97401287688101.031641718
2178343.71207881687707.6367884812178500.71914024687580.320805838
#Sta/Elev= 30
       0 1474.63    47.9 1460.34   124.1 1441.07   160.3 1441.27   174.3 1439.93
   197.6  1435.4   222.4 1428.49   243.2 1425.96  268.88 1426.21   280.4 1423.17
   284.6 1423.15   301.1 1423.43   313.6  1426.2   338.4 1425.29     355 1426.98
     413 1426.58   466.8 1428.21   477.9 1431.39   487.7 1437.97   495.8 1441.01
   537.2 1443.41     553  1446.2   568.6 1454.17   582.8 1466.76   600.3 1476.89
   693.7 1523.45   699.4 1525.62     708 1527.11   723.9 1534.45   765.8 1549.49
#Mann= 5 ,-1,0
       0     .05       0  268.88    .045       0   313.6     .05       0
  623.69     .06       0  643.69      .1       0
Bank Sta=268.88,313.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,40597   ,483.9,509.8,530.4
XS GIS Cut Line= 3
2178562.24056177688395.8001528632178861.27686915688084.144158502
2178901.68507972687951.609173355
#Sta/Elev= 30
       0 1513.45    14.7 1508.68      40 1498.48    59.1 1488.14    70.2 1485.81
    86.8 1475.32   119.2 1458.87   129.9 1451.99   141.5 1449.48   161.6 1435.56
   170.3 1430.67   176.1 1428.42   187.1 1426.27   212.6 1424.64   222.3 1422.64
   247.5 1422.96  255.42  1424.5   268.6 1431.91   274.3 1434.11   325.7 1437.96
   341.8 1441.35   368.2 1442.05   389.9 1446.79   404.9  1447.7   424.7  1451.8
   456.1 1455.02   489.4 1465.45   519.9 1478.32   547.9 1487.97   570.5 1497.75
#Mann= 3 ,-1,0
       0      .1       0   212.6    .045       0  255.42      .1       0
Bank Sta=212.6,255.42
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,40087   ,454.1,495.3,532.6
XS GIS Cut Line= 2
2178745.22184505688607.7159431982179339.86629602688585.763337359
#Sta/Elev= 30
       0 1515.64      51 1503.99      91 1489.11     107  1480.8     123 1469.95
   163.1 1447.37   175.1  1439.4   179.1 1437.28   187.1  1436.7   190.6 1435.39
   199.1 1430.36     206 1428.85   219.1 1428.31   251.1 1429.43  276.57 1425.28
   299.2 1422.45   323.2 1423.28   327.2 1425.25   335.2 1433.62   343.2 1438.87
   366.2 1443.53   399.2 1451.85   435.2 1464.55   447.3 1467.48   456.9 1472.26
   479.3 1474.92   491.3 1480.86   519.3 1488.63   539.3  1496.3     595 1521.26
#Mann= 3 ,-1,0
       0      .1       0  276.57    .045       0   327.2      .1       0
Bank Sta=276.57,327.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,39591   ,431.1,435.1,432.1
XS GIS Cut Line= 2
2178735.82623404688668.3924423352178927.45966954689172.953767617
#Sta/Elev= 30
       0 1505.26    13.7 1501.29    52.2 1483.68    68.6  1478.1    82.1 1468.15
   116.4 1449.29   131.1 1442.97   137.8 1438.92   150.6  1435.4   174.5 1431.14
     249 1431.72   270.4 1430.51   283.2 1426.99   290.61426.606   301.7  1422.4
   334.6 1422.15     342 1423.54  346.371426.606   351.7 1430.44   373.1 1434.63
   381.7 1437.74   419.5 1464.06   437.3 1474.55   441.6  1476.2   450.1  1477.4
   458.7  1484.3   487.7 1499.78   497.2 1501.17   509.4  1507.6   539.7 1518.91
#Mann= 3 ,-1,0
       0      .1       0   290.6    .045       0  346.37      .1       0
Bank Sta=290.6,346.37
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,39156   ,485.7,468.1,457.2
XS GIS Cut Line= 2
2178334.49332701 688779.113218582178515.98608261689296.037158327
#Sta/Elev= 30
       0 1517.98    21.8 1509.54    27.6  1505.8    43.7 1502.51    53.1 1496.52
    78.5 1484.12   112.4 1465.43   120.9 1459.34   133.6  1457.1   147.3 1448.57
   184.9 1434.04   197.2 1431.68   209.9 1426.48   214.2 1425.92   238.3    1428
   252.3 1427.01     265 1428.05  270.98 1424.43   273.5 1422.61   277.7 1422.01
   294.7 1421.78   307.4 1422.13   315.9 1424.48   329.3 1423.31   341.3 1428.93
   379.6 1443.12   415.6 1460.55     460 1483.71   476.7 1490.93   547.9    1509
#Mann= 3 ,-1,0
       0      .1       0  270.98    .045       0   315.9      .1       0
Bank Sta=270.98,315.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,38688   ,511.5,498.2,472.7
XS GIS Cut Line= 3
2177814.40680378689020.3224956862178160.22933046689334.152910484
2178267.91222376689459.683001725
#Sta/Elev= 30
       0 1544.03    29.4 1529.83    56.4  1519.6    69.8  1512.1    84.6 1508.27
    94.2 1502.98   123.6 1489.13   153.6 1472.51     186 1458.22   223.9 1443.11
   233.4 1437.11   245.5 1432.06  252.15    1425   256.7 1422.38   270.9 1423.48
   292.9 1422.21   299.5 1424.92   304.8 1426.25     319 1424.83   328.6 1426.16
   344.5 1426.36   370.3 1432.15   412.5 1430.93   435.1 1433.85   457.8 1443.38
   483.3 1457.08   513.1 1474.95   540.6 1488.64   571.3 1499.43   632.4 1513.67
#Mann= 3 ,-1,0
       0      .1       0  252.15    .045       0   299.5      .1       0
Bank Sta=252.15,299.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,38190   ,488.6,498.4,497.2
XS GIS Cut Line= 2
2177428.63302754689588.9682461182178173.79707226689672.020827869
#Sta/Elev= 30
       0 1580.71    51.9 1562.28      68 1555.11      76 1550.33   116.3 1532.99
   128.3 1529.06   140.4 1522.58   151.9 1520.12   168.6 1512.76   208.8 1497.62
   242.4 1482.15   297.4 1452.04   329.6  1438.5   337.6 1433.86   345.7 1432.33
   353.7 1428.55  360.75 1423.65   365.8 1421.49   373.8 1421.28     406 1421.64
   422.1  1423.7   438.2 1428.21   465.8 1428.69   502.6 1431.74   550.9 1438.78
   582.8 1450.31     656 1489.72   675.7 1499.25   691.8 1504.89   749.8 1518.43
#Mann= 4 ,-1,0
       0     .05       0      70      .1       0  360.75    .045       0
   422.1      .1       0
Bank Sta=360.75,422.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,37692   ,545.2,539.4,525.6
XS GIS Cut Line= 2
2177507.21652668690038.8845077652178099.96182614690180.398001725
#Sta/Elev= 30
       0 1549.66    21.5 1538.51    35.9 1532.39    99.7 1513.38   124.4 1500.72
   136.7 1497.45     149 1488.69     186 1466.98   202.5 1459.16   243.6 1445.21
   276.5 1437.34   297.1 1435.43   305.3 1432.22  315.16 1424.69   317.6 1422.82
   325.9 1420.97   358.8 1420.91     367 1421.68   375.2 1424.68   387.6 1422.55
   391.7 1423.08   399.9 1426.28   436.9 1427.09   445.1 1428.82   457.7  1435.3
   469.8 1438.47     478 1443.24   511.4 1457.26   531.5 1467.86   609.4 1517.74
#Mann= 3 ,-1,0
       0      .1       0  315.16    .045       0   375.2      .1       0
Bank Sta=315.16,375.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,37152   ,488.5,452.9,422.6
XS GIS Cut Line= 4
2177191.04989847690774.3215713992177378.31391986690654.059403031
2177886.93919277690635.8722185792178002.58164718  690528.2106781
#Sta/Elev= 30
       0 1502.52    20.4  1498.1    48.9 1490.08    98.3 1478.11     128 1468.17
   172.5 1451.49   186.7 1447.27   216.8 1441.37   252.4 1432.68   271.6 1426.94
   312.5 1425.53   376.5 1424.81   424.5  1425.4   464.6 1426.84   512.6 1430.79
   548.6 1431.19   565.3 1430.67   628.7 1425.26   636.7 1421.32   656.7 1420.93
   672.7 1421.19  687.95 1425.29   692.7 1428.02   704.7 1437.84   708.7 1438.73
     766 1441.75   802.2 1446.68     856 1456.51   870.5 1461.02   889.5 1468.66
#Mann= 4 ,-1,0
       0      .1       0   628.7    .045       0  687.95     .05       0
  741.51      .1       0
Bank Sta=628.7,687.95
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,36699   ,518.2,466.3,416.9
XS GIS Cut Line= 4
 2177619.7315783691294.2965885842177675.47233736691122.748679826
2177910.88848609 690786.830093212178016.95870226690526.888178963
#Sta/Elev= 30
       0 1517.23    45.7  1502.5    97.9 1480.17   110.5 1473.35   118.9 1471.75
     140 1462.97     161 1453.88   173.6 1443.38   182.3 1442.17   201.8 1429.04
  212.651425.415   222.2 1420.68   265.3 1420.44   270.2 1421.35   275.1 1425.38
     280 1427.58   309.3 1425.09   314.2 1426.19   323.9 1430.92   328.8 1431.96
   418.6 1429.13   480.7 1429.06   506.5 1430.31   543.7 1435.87   568.2 1437.93
   694.1 1441.25   767.7 1447.37   821.3 1455.66   848.1  1461.6   871.3    1472
#Mann= 3 ,-1,0
       0      .1       0  212.65    .045       0   275.1      .1       0
Bank Sta=212.65,275.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,36233   ,497.5,505.3,510
XS GIS Cut Line= 3
2178306.89105508691054.9496368282177976.68583477690722.490889848
2178033.00717558690527.439290841
#Sta/Elev= 30
       0 1495.05    45.6 1468.88    71.1 1457.11   109.6 1442.46   124.8  1441.1
   137.8 1435.58   147.4 1433.02   164.4 1430.91   192.7 1429.63   287.7 1429.71
     320 1430.62   351.1 1430.34   356.7 1429.23   368.9 1423.84   374.6 1423.18
   384.2 1424.74  389.01 1423.22   395.5 1420.72   404.8 1420.24   421.8 1420.58
   430.3 1423.24   441.6 1425.47   447.9  1428.7   457.9 1435.87     467 1439.91
   553.2 1446.72   615.7 1455.35   637.2 1460.12   657.3 1467.64   671.6  1474.3
#Mann= 9 ,-1,0
       0      .1       0     220     .05       0     320      .1       0
     350     .06       0  389.01    .045       0   430.3     .06       0
     460      .1       0  518.58     .05       0  588.58      .1       0
Bank Sta=389.01,430.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
