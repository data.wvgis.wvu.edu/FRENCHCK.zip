HEC-RAS study FRENCHCK.prj: FRENCHCK

--- FRENCHCK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,35728   ,489.7,500.3,503.2
XS GIS Cut Line= 3
2178638.21699655690835.1836264752178382.29902649690404.927883258
2178246.95367299690291.912714266
#Sta/Elev= 30
       0 1493.12    32.1 1481.88    66.6 1471.43   100.1 1462.48   110.9 1457.74
     184 1443.29   230.4 1430.18     249 1427.76   340.5  1425.5   365.4  1423.2
   379.6  1424.6   388.6 1420.85   393.3 1420.16   420.3 1420.07   425.9 1420.79
  430.17 1424.59   435.2 1428.14     467 1433.07   478.6 1437.01   487.4 1441.76
   495.7 1443.23   501.9 1447.43   512.7  1452.2   545.1 1470.04   555.9 1477.51
   568.9  1484.7   597.2 1504.42   621.2 1518.45   637.5  1525.1   676.9 1535.28
#Mann= 5 ,-1,0
       0      .1       0     120     .05       0     270      .1       0
   379.6    .045       0  430.17      .1       0
Bank Sta=379.6,430.17
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,35227   ,475.8,486.3,490.6
XS GIS Cut Line= 3
2178952.39052867690669.0903278792178936.51897951690463.506713106
2178796.10117879690019.735346307
#Sta/Elev= 30
       0 1517.93      20 1513.03   104.4 1485.34   124.3 1477.81   148.4 1467.01
   156.5 1461.57   168.4 1459.64   180.4 1452.99   225.4 1441.51   262.5 1430.08
     280 1426.81   305.1 1424.92   355.5 1425.28   372.3 1422.25     389 1423.44
   397.4 1420.78   422.6 1420.21   426.8 1420.66   435.2 1423.51   447.4  1424.8
   472.5 1425.46   493.9 1434.23   506.5  1435.6     510 1436.84   535.9 1446.79
   556.9 1456.27   569.4 1463.04   611.4 1482.19   661.7 1507.69   671.7 1511.07
#Mann= 3 ,-1,0
       0     .05       0     389    .045       0   435.2      .1       0
Bank Sta=389,435.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,34741   ,565.2,618.2,666.2
XS GIS Cut Line= 4
2178991.68992508690661.5001468282179338.12031518690346.563428551
2179324.85982178690043.2296420012179271.81784817689862.555419411
#Sta/Elev= 30
       0 1517.69    76.3 1503.35   130.8 1488.27     179 1478.54   222.3 1461.98
   235.6 1458.41   249.8 1458.46   265.5 1454.78   346.6 1444.84   477.6 1442.06
   501.6 1435.88   533.6 1423.75   541.6 1422.93   581.7 1426.03   617.7 1424.24
   633.7 1426.55   649.7 1422.61   665.8 1423.43   673.8 1420.09   697.7 1419.81
   701.8 1420.32  706.86 1423.31   713.8 1431.77   717.8 1433.42   761.9    1439
   786.5 1445.15   815.9 1454.93     924 1504.92   953.2 1516.05   960.1 1516.94
#Mann= 5 ,-1,0
       0      .1       0      80     .05       0     110      .1       0
   665.8    .045       0  706.86      .1       0
Bank Sta=665.8,706.86
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,34123   ,590.8,596,584.7
XS GIS Cut Line= 3
2179002.38436371690670.0299403542179358.22822488690356.497537565
2179780.00312615690516.961313202
#Sta/Elev= 30
       0 1515.76    66.4  1501.4     157 1476.95   188.9 1470.59   215.6 1463.16
   225.8 1457.62   231.6 1456.61   249.4 1456.74   311.6 1447.71     342 1444.78
   474.3 1441.48   549.1 1432.41   587.6  1429.5   634.7 1429.78   677.5 1423.21
   711.9 1422.03   720.3 1419.56   727.4 1419.12     746 1419.32  753.53  1421.9
   767.4 1433.56   775.9 1444.72   780.2 1446.57   792.5 1446.74   795.6 1448.01
   804.9 1456.33   826.6 1465.78   861.5 1485.06   882.9 1495.14   925.5 1519.73
#Mann= 5 ,-1,0
       0      .1       0   711.9    .045       0  753.53      .1       0
  804.27     .06       0  914.27      .1       0
Bank Sta=711.9,753.53
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,33527   ,407.6,404.2,397.2
XS GIS Cut Line= 3
2179052.10245838690706.7896936532179510.86694264690865.602722846
2179583.62629492690984.459368279
#Sta/Elev= 30
       0 1488.85    58.5 1454.26    67.8 1445.03    76.3 1444.89    80.5 1443.51
    84.7 1438.72    93.2 1426.58   96.781423.301   101.7 1419.99   105.7    1419
   118.3 1418.88     134 1420.11  141.231423.299   148.2 1425.61   266.7 1428.91
   296.4  1429.1   338.4  1431.1     351 1432.55   355.6  1434.7   364.1 1440.57
     373 1444.19   379.3  1444.5   402.2 1443.21   414.9 1450.31   448.8 1454.25
   494.4 1463.29     511 1467.59   541.3 1477.26   588.2 1495.79   624.8 1511.76
#Mann= 6 ,-1,0
       0      .1       0   96.78    .045       0  141.23      .1       0
     340     .06       0     440     .07       0  595.48      .1       0
Bank Sta=96.78,141.23
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,33123   ,497.8,485.9,472.1
XS GIS Cut Line= 3
2178860.04101777691106.4075880712179290.05775787691163.185259898
2179455.14831497691220.592821573
#Sta/Elev= 30
       0 1533.87     8.2  1528.8    16.3 1527.58    76.8 1482.94    84.9 1475.63
      97  1470.8   116.6 1456.83   125.2 1448.38   137.3 1445.94   149.4    1435
   157.5 1424.85   161.5 1421.85   173.6 1419.19   185.7 1421.31   193.8 1420.86
   205.9 1418.56   226.1 1418.94   230.1  1420.9   237.8  1424.2   262.4 1427.44
   326.9 1430.12   363.3 1433.99   452.9 1452.33   469.9 1452.46     481 1458.75
   495.3 1461.71   509.3 1466.84   554.6 1488.17     580 1497.82   608.5 1512.13
#Mann= 5 ,-1,0
       0      .1       0   193.8    .045       0   230.1      .1       0
  523.75     .06       0  553.75     .07       0
Bank Sta=193.8,230.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,32637   ,528.8,502.5,462
XS GIS Cut Line= 3
2178813.29757259691635.5515680182178993.34748675691641.119096835
2179406.89866092691509.793722334
#Sta/Elev= 30
       0 1529.46    10.9 1525.96    74.9 1492.99   110.9 1478.74   138.9 1464.88
     175 1450.63   191.5 1442.77   208.3 1439.07   216.7 1433.22   233.5  1431.9
   246.1 1426.65     262 1422.49   275.4 1418.16     309  1418.3   313.2 1418.95
   319.9  1422.5   325.8 1424.38   355.2 1423.31   376.2 1425.63   405.5 1426.39
   430.6 1432.52   440.4 1437.29   455.9 1450.05   464.3 1453.59   475.4 1455.29
   497.9 1455.51   526.4 1464.17   539.1 1470.19   589.6 1498.76     614 1510.19
#Mann= 4 ,-1,0
       0      .1       0     262    .045       0   319.9      .1       0
  580.14     .07       0
Bank Sta=262,319.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,32134   ,525.3,564.3,563
XS GIS Cut Line= 2
 2179410.2541698692171.3986850252179534.47813883691633.593761927
#Sta/Elev= 30
       0 1522.11    22.8 1510.12    33.5 1507.05    66.8  1490.4    84.4 1483.89
     109 1472.97   129.5 1466.44   141.9 1461.14   154.2 1459.57   178.8 1451.03
   191.1 1441.91   195.2 1439.72   207.5 1438.38  227.311422.548   232.2 1418.98
   236.3 1418.34   269.1 1418.99  278.271422.549   285.5 1424.63   310.2 1422.81
   330.7 1427.83   388.2 1430.89   404.6  1433.8   425.1 1441.64   449.8 1452.74
     458  1457.6   478.5 1459.95   486.7 1464.64   507.2 1472.91     552 1497.58
#Mann= 4 ,-1,0
       0      .1       0  227.31    .045       0  278.27      .1       0
     500     .07       0
Bank Sta=227.31,278.27
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,31570   ,324.3,356.4,352.8
XS GIS Cut Line= 3
2179763.03820482692210.0407642122180101.33545381691812.261052791
2180181.15095584691638.703847969
#Sta/Elev= 30
       0 1507.64    63.5  1483.9    79.9 1476.13    92.2 1467.53   127.2 1465.64
   142.9 1456.17   174.4 1442.97   211.2 1429.98   242.7 1426.53   299.4  1427.2
   319.2 1423.59  338.54 1422.26   350.4 1418.27   389.7 1417.82     395 1418.65
  401.131422.263   410.7 1431.31   415.4 1434.11   461.1 1445.03   475.3 1452.21
   495.7 1466.17     508 1468.59   538.8 1469.76   543.2 1471.11   553.8  1478.9
   559.8 1481.42   605.1 1487.36   626.8 1500.68   648.8 1510.66   713.2 1532.49
#Mann= 6 ,-1,0
       0      .1       0  338.54    .045       0  401.13      .1       0
  552.18     .07       0  652.18     .06       0  662.18      .1       0
Bank Sta=338.54,401.13
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,31214   ,391.2,413.6,419.4
XS GIS Cut Line= 2
 2179950.3112001692340.9093256952180454.09595797 692050.11266935
#Sta/Elev= 30
       0 1484.99    34.5 1470.08    39.1 1467.21    48.3 1457.98      89 1454.94
   109.5 1444.59   140.7  1434.1   200.7 1424.19   237.7 1424.41  261.081422.111
     270 1418.13   274.6 1417.81   314.5    1418   317.4  1418.7  322.511422.108
   326.2 1424.72   335.5 1427.79   351.5 1435.05     367 1444.69   376.3 1446.79
     404 1459.66   431.7 1470.86   440.9 1476.07   445.5 1477.73   459.4 1478.12
   463.5 1479.54   473.2 1488.23   522.4 1508.27   557.5 1524.34   581.7 1534.33
#Mann= 4 ,-1,0
       0      .1       0  261.08    .045       0  322.51      .1       0
     580     .06       0
Bank Sta=261.08,322.51
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,30800   ,397.5,414.9,418.4
XS GIS Cut Line= 3
2180034.38099689692618.9848510872180452.78800982692551.979229581
2180592.74035575692450.313643751
#Sta/Elev= 30
       0 1459.95      14 1455.88    58.5    1454    62.6 1453.08    70.7 1447.85
    78.8  1445.9   131.4 1442.48   163.9 1426.84   192.2 1427.18   200.3 1425.49
   240.8 1424.52     253 1421.86   273.2 1421.32   281.3  1418.1   309.7 1417.74
   321.8    1418  330.48 1421.31   346.1 1428.32   361.7 1440.83   382.6 1452.31
   394.8 1452.43   398.8 1455.13   406.9 1464.98     411 1467.33   442.8  1472.3
   472.4 1491.19   499.8 1505.32     557 1539.14   571.4 1544.46   596.7 1550.47
#Mann= 6 ,-1,0
       0      .1       0     130     .05       0   273.2    .045       0
  330.48      .1       0  423.74     .06       0  543.74      .1       0
Bank Sta=273.2,330.48
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,30385   ,142,136.2,119.5
XS GIS Cut Line= 3
2180060.91487073692921.1821427012180485.73503257692981.176220264
2180639.81793847693051.402737849
#Sta/Elev= 30
       0 1487.41    27.5 1474.34    80.8 1455.17    84.1 1453.43   100.2 1439.98
   132.6 1436.24   152.8 1420.99   156.8 1419.52   164.9 1420.31     177 1417.98
   201.2 1417.37   213.4 1417.57   229.5 1420.42   269.9 1419.76     282 1421.99
   314.4 1424.07   321.5 1425.59   342.6 1434.58   370.9 1434.73   378.1 1436.52
   387.1  1436.2   395.8 1437.65   436.9 1453.78   464.1 1457.13   485.2 1469.57
   510.8 1479.46   532.8 1482.93   542.6 1489.85   550.4 1493.83   598.4 1511.49
#Mann= 5 ,-1,0
       0      .1       0   164.9    .045       0   229.5      .1       0
     400     .08       0  499.04     .06       0
Bank Sta=164.9,229.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,30249   ,59.3,52.9,50.3
XS GIS Cut Line= 4
2179937.38266029693046.211168555 2180123.6289545 693106.72513288
2180384.47071861693042.0997093092180627.83375078693128.096611685
#Sta/Elev= 30
       0 1515.49    82.8 1473.51     122 1455.51   145.9 1446.32   162.8 1436.85
     176 1435.16   212.9 1435.58   240.5  1428.7   250.4 1422.29   254.1 1421.28
   282.9 1421.11  298.97 1418.82   303.5 1417.57   332.4 1417.34   344.7 1418.85
   361.2 1419.46   386.2 1423.08     423 1426.34   451.9 1437.63   515.2 1443.68
   535.7 1452.23   549.1 1452.73   557.6 1454.42   567.1 1458.84   582.7 1470.23
   587.3  1472.5   608.5  1480.1   655.8  1500.1   686.2 1510.94   722.7 1528.19
#Mann= 9 ,-1,0
       0      .1       0      90     .08       0     130     .07       0
  298.97    .045       0   344.7     .06       0  345.83      .1       0
  534.56     .08       0  554.56     .06       0  644.56      .1       0
Bank Sta=298.97,344.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,30196   ,186,214.8,248
XS GIS Cut Line= 4
2179931.70091432693093.8399019552180117.94720853 693154.35386628
2180378.78897264693089.7284427092180622.15200481693175.725345085
#Sta/Elev= 30
       0 1496.99      72 1463.39   126.7 1441.42   139.3  1433.3     184 1433.91
   195.8 1432.28   231.7    1430   238.3 1428.79   255.8 1421.74   276.4 1420.06
   292.9 1417.56     330 1417.33  338.59 1419.98   342.4 1421.26   371.2 1422.53
   412.4 1426.56   424.8 1428.97   439.7 1434.32   461.9 1440.01   490.3  1439.9
   515.4 1443.73   529.7 1450.31   555.1 1464.86   563.6 1471.19   567.8 1473.26
   589.1 1480.43     640 1501.93   648.5 1504.74   707.8 1530.56   722.7 1535.98
#Mann= 6 ,-1,0
       0      .1       0      30     .08       0     140     .07       0
   276.4    .045       0  338.59     .06       0  644.56      .1       0
Bank Sta=276.4,338.59
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,29981   ,813.6,829.3,840
XS GIS Cut Line= 2
2179910.73815873 693114.362071352180267.28136246693441.781171158
#Sta/Elev= 30
       0  1493.2    10.1 1487.89    39.8 1474.94    76.6 1454.84    99.3 1444.69
   122.4 1431.61   175.7 1428.75   205.2 1428.52   229.5 1430.01   235.5 1428.04
   246.3  1422.2     255 1420.37   264.4 1419.51   277.6 1420.72   286.1 1420.51
   293.9  1417.7   299.9 1417.29   322.4 1417.83  327.35 1420.44   344.1 1431.06
   354.9 1441.57   362.5 1447.51   382.4 1456.68     393 1462.89   410.7 1464.56
   413.5 1465.92   420.1 1471.11   441.8 1478.96   458.1  1486.3   484.1 1488.11
#Mann= 6 ,-1,0
       0      .1       0      70     .08       0      90     .07       0
     200      .1       0   286.1    .045       0  327.35      .1       0
Bank Sta=286.1,327.35
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,29152   ,502.9,517.5,524.7
XS GIS Cut Line= 2
2179287.31084154693251.9915128472179406.70850017693754.271404979
#Sta/Elev= 30
       0 1498.93    13.6  1492.1    54.7 1474.25    71.1  1463.8    79.3 1459.62
    91.7 1456.38   108.1  1454.4   128.7 1441.61     141 1438.32   157.5 1435.66
   169.8 1426.54   173.9 1424.82   202.7 1424.03     215 1421.76  220.46 1419.14
   223.2 1417.21   227.4 1416.44   256.1 1417.03   268.5 1419.68   280.8 1416.99
   290.7 1416.65     304 1417.93   307.9 1419.15   317.8 1424.45   330.1 1428.27
   338.4 1429.03   379.5    1445   432.9 1459.03   453.5 1467.28   516.3 1496.03
#Mann= 5 ,-1,0
       0      .1       0     120     .06       0     220      .1       0
  220.46    .045       0   307.9      .1       0
Bank Sta=220.46,307.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28634   ,530.8,540.8,526.3
XS GIS Cut Line= 2
2178855.30761914693308.2084203182178849.16414913693802.186709785
#Sta/Elev= 30
       0  1514.7       5 1511.38      25 1500.72      41 1493.51      49 1489.03
      73 1476.67     105 1457.16     145 1437.78     153 1430.92     157 1429.23
     173 1429.12     177 1427.91   190.9 1418.79     193 1417.61     197  1416.7
   209.5 1416.05     233  1416.4     241 1417.99     253 1418.91     265 1418.93
     277 1418.36     281 1418.63   304.3 1425.32     321 1429.06   383.4 1437.59
     405  1442.4     437 1451.25     465 1455.78   478.2  1459.5     494 1466.26
#Mann= 7 ,-1,0
       0      .1       0      60     .06       0     160      .1       0
   190.9    .045       0     253      .1       0     260     .05       0
     360      .1       0
Bank Sta=190.9,253
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28094   ,549.5,560.4,550.9
XS GIS Cut Line= 2
2178350.54584944693256.3038436362178340.01853508693772.697044147
#Sta/Elev= 30
       0 1525.21     4.9 1523.33    12.9 1521.99    44.9 1510.35    80.9 1491.85
     109    1479   132.9 1469.55   148.9 1462.11   160.9 1455.99   168.9 1450.57
   184.9 1444.69   200.9 1441.89   212.9 1438.31   220.9 1430.21   224.9 1427.12
   244.9 1426.92   248.9 1425.63  257.13 1419.47   260.9 1417.64   264.9  1416.7
   284.9 1415.96   312.9 1416.41   324.9 1419.44   344.9 1419.54     369 1425.02
     397 1428.82     433 1436.42     461 1444.23     469 1447.09   516.5 1467.42
#Mann= 6 ,-1,0
       0      .1       0     110     .06       0     210     .05       0
  257.13    .045       0   324.9     .05       0     410      .1       0
Bank Sta=257.13,324.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,27533   ,471.1,470.2,465.3
XS GIS Cut Line= 3
 2177900.3840873693222.1012532772177835.64210071693338.443419576
2177789.75989652693710.648268684
#Sta/Elev= 30
       0 1498.78    26.4  1487.5      63 1472.99    84.8 1465.91   108.8 1457.09
   125.9 1448.93   149.5 1438.87   160.1 1437.15   180.2 1432.55   196.1 1427.56
   232.6 1426.06   236.7 1424.21  243.27  1419.8   248.7 1417.72   256.8 1416.08
     277 1415.85     289 1416.18   309.2 1419.86   325.3 1420.88   337.4 1419.16
   345.5 1418.95   353.5 1419.57   357.6 1420.75   369.7 1426.65   393.5 1434.96
     414 1445.28   422.2 1447.81   442.2 1457.59   478.5 1472.96   508.2 1486.91
#Mann= 5 ,-1,0
       0      .1       0      60     .06       0  163.14     .07       0
  243.27    .045       0   309.2      .1       0
Bank Sta=243.27,309.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,27063   ,168.8,146,172
XS GIS Cut Line= 2
  2177369.041916 693163.168286592177342.06508769693660.236098117
#Sta/Elev= 30
       0 1513.75      10 1510.21      22 1503.21    30.1 1500.37    42.1 1498.15
    58.1 1497.98    66.1 1496.78   106.2 1475.31   130.2 1461.03   134.2 1459.15
   143.3 1457.02   154.2 1451.16   170.3 1443.89   178.3 1438.54   194.3 1436.54
   198.3 1433.96   202.3 1429.87   206.3 1426.89   234.4 1424.59   246.4 1419.12
   258.4 1418.08   266.4 1416.03   298.4 1416.52   306.5 1418.27   334.5 1417.83
   354.5 1422.56   386.6 1424.31   398.6 1426.14   442.7 1443.77   497.8 1467.86
#Mann= 5 ,-1,0
       0      .1       0     110     .07       0   258.4    .045       0
   306.5     .07       0     310     .05       0
Bank Sta=258.4,306.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,26917   ,66.9,66.4,44.6
XS GIS Cut Line= 6
2177016.49005646693191.1439621352177152.67539778693417.095597064
2177210.67679591693452.1381084382177213.09352084693469.055182894
2177187.71790915693521.014768725 2177210.8340455  693686.3172153
#Sta/Elev= 30
       0 1513.58    30.4    1502    67.8 1492.19    88.7 1484.18   132.4 1463.78
   141.1 1456.14   149.9 1450.16   156.5 1444.44   161.5 1441.46   170.5 1440.41
   184.5 1440.82   203.2 1437.05   226.6 1434.39   240.2 1428.77   266.6 1426.96
   284.6 1420.81   288.9 1421.24   293.2 1423.53   297.3 1423.24   309.3 1417.43
   313.8 1416.36   346.6 1415.22   390.5 1415.32     403 1417.07   421.3  1422.2
   433.4 1423.63   461.7 1431.87   497.9 1441.04   522.3 1449.63   575.9 1471.66
#Mann= 4 ,-1,0
       0      .1       0     210     .07       0   309.3    .045       0
     403     .05       0
Bank Sta=309.3,403
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,26851   ,226.8,244.1,232
XS GIS Cut Line= 6
2176954.91616044693213.2156663172177091.10150175693439.167301246
2177149.10289989 693474.209812622177151.51962481693491.126887076
2177126.14401313693543.0864729072177149.26014947693708.388919482
#Sta/Elev= 30
       0 1521.27    18.6 1512.02      42 1501.93    79.4 1490.58   108.7 1478.02
   126.1 1469.28   137.8 1462.21   154.1 1449.12   164.1 1444.48   172.8  1437.9
   175.7 1436.63   200.8  1432.5   219.5 1431.94     234 1427.66   269.5 1425.68
   277.8 1423.84     288 1419.91  308.42 1416.35   317.7 1414.53   323.2 1414.49
   357.3 1414.84   365.7 1416.41   374.2 1416.64   406.8  1421.1   415.1 1420.35
   423.2 1420.99   451.3 1431.31   467.7 1434.85   491.9 1441.91   575.9 1477.53
#Mann= 5 ,-1,0
       0      .1       0     180     .06       0  283.82     .07       0
  308.42    .045       0   365.7     .05       0
Bank Sta=308.42,365.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,26607   ,598.3,597.7,594.5
XS GIS Cut Line= 2
2176844.70403787693270.950943859 2176967.0320895693718.492596146
#Sta/Elev= 30
       0 1515.64    14.7 1507.77    39.6 1497.25    64.5 1489.49    81.1 1483.16
     106 1468.64   114.3 1462.81   147.4  1443.7   168.2  1435.5   176.5 1431.21
   180.6  1427.8   184.8 1426.77   196.8 1426.76   201.4 1425.74   205.5 1423.03
   212.2 1417.02   213.8 1415.65   217.9 1414.67     247 1415.57     255 1417.03
   271.8 1415.95   280.1 1416.26   297.7  1420.7   325.8 1421.95   350.6  1428.8
   363.1 1430.17   375.9 1433.92   398.7 1438.67     454 1460.77     464 1463.22
#Mann= 5 ,-1,0
       0      .1       0     100     .06       0     210     .05       0
   212.2    .045       0     255     .05       0
Bank Sta=212.2,255
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,26009   ,199.7,200.7,202.3
XS GIS Cut Line= 3
 2176265.9684171693450.6244314172176379.55898889693781.153332014
 2176603.5825972693779.661815437
#Sta/Elev= 30
       0 1487.58    11.2 1484.81    32.3 1477.09    70.4 1468.82     100  1459.4
   112.7 1452.45   125.4 1444.02   129.6 1440.68   133.8 1436.18     138 1433.33
     155 1432.71   159.2    1430   167.4 1421.72   171.9 1418.89   176.1 1416.97
   184.6 1415.84     193  1414.1   198.9 1414.02   214.2 1414.22   224.1 1415.83
   274.5 1423.96   349.5 1428.09   446.8  1432.1   482.1 1435.02   510.1 1436.53
   526.1 1436.09   542.1 1436.61   551.5 1437.63   562.1 1439.94   573.5 1440.89
#Mann= 6 ,-1,0
       0      .1       0      20     .06       0     120     .05       0
   184.6    .045       0   224.1     .05       0   489.5     .06       0
Bank Sta=184.6,224.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,25808   ,26.8,27.4,33.3
XS GIS Cut Line= 3
2176077.09558166693494.203450272 2176173.8854148693809.586052638
 2176578.4451668693791.098106982
#Sta/Elev= 30
       0 1475.82    28.2  1468.8    36.9 1467.89    57.5 1460.43    70.1 1459.24
      91 1453.72   141.2  1436.2   149.6 1430.29   153.7 1429.48   174.7 1428.95
   201.1 1415.56     204 1414.51     215 1414.04   224.9  1414.2   233.2  1415.6
   254.2 1416.79   266.7 1420.15   279.3 1424.96   291.8  1427.4   344.2 1429.41
   412.9 1427.61   458.8 1427.71   560.4 1430.81   592.5 1432.74   612.5 1434.94
   652.5 1436.29   708.6 1436.95   713.7 1437.87   724.6 1441.63   734.9  1443.2
#Mann= 7 ,-1,0
       0      .1       0      80     .06       0     180      .1       0
   201.1    .045       0   233.2      .1       0     280     .05       0
   669.9     .06       0
Bank Sta=201.1,233.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,25781   ,239.6,240,239.3
XS GIS Cut Line= 3
2176052.62624182693505.0787124222176149.41607496693820.461314789
2176553.97582696693801.973369133
#Sta/Elev= 30
       0 1472.39    46.1 1460.28    75.4 1455.62      88 1452.71     115 1444.01
   137.4 1435.83   146.5 1429.71   163.3 1429.81   167.5 1429.21   171.7 1427.46
   184.2 1420.89   188.6 1418.95   195.7 1416.68   200.9 1414.82   205.1 1414.28
     226 1413.97   251.2 1416.68   263.7 1419.79   272.1 1423.23   280.4 1425.41
   322.3  1428.8   384.7 1429.56   436.8 1427.56     485 1428.05   568.9 1431.29
     625 1434.46     645 1436.03   709.1 1436.73   729.1 1438.88   734.9 1439.99
#Mann= 6 ,-1,0
       0      .1       0      70     .06       0   195.7    .045       0
   251.2      .1       0     270     .05       0   699.9     .06       0
Bank Sta=195.7,251.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,25541   ,406,406.3,405.4
XS GIS Cut Line= 3
2175820.51813185693567.7813690762175912.23678793693859.965715382
2176561.31111994693806.258077311
#Sta/Elev= 30
       0 1463.28      14 1461.03    89.5 1443.46   110.5 1436.05   128.5  1432.8
   131.7 1431.54   139.8 1426.47   156.6 1426.86   160.8 1425.81   169.2 1421.09
   173.1 1419.61   194.3 1416.41   206.9 1414.34   211.1 1414.31   227.9 1414.47
   244.6  1416.4   265.4  1420.6   289.9 1421.18   306.2 1423.53   362.4 1424.42
   447.5 1428.59   542.3 1429.47     551 1430.07     672  1427.5   783.8 1432.13
     848 1436.07   920.1 1436.72   950.1 1440.38   952.4 1440.83   957.5 1443.76
#Mann= 5 ,-1,0
       0      .1       0     100     .07       0   194.3    .045       0
   244.6     .05       0  916.24     .06       0
Bank Sta=194.3,244.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,25135   ,911.8,848.2,771
XS GIS Cut Line= 3
2175392.62649508693562.440260703 2175521.5479587 693959.43651376
2176550.16954775693813.505193156
#Sta/Elev= 30
       0 1478.33    32.3 1466.51    53.3 1460.05      87 1451.72    95.4 1447.73
   116.4 1443.03   150.1 1429.49   154.3 1428.71   162.7 1430.95   171.1  1431.6
   192.1  1431.5   221.6 1426.27   255.2 1422.86   284.7 1421.23   301.5 1417.38
   318.3 1416.23   330.9 1414.23   351.9 1415.04  358.82 1416.24   376.4 1419.43
     400 1422.12   417.4 1426.09   533.2 1424.17   606.2 1426.64   963.1  1429.7
  1180.5  1427.6  1302.7  1432.9  1333.1 1435.38    1426 1436.85  1456.3 1440.47
#Mann= 9 ,-1,0
       0      .1       0     110     .07       0     130     .08       0
     210      .1       0   318.3    .045       0  358.82     .05       0
  1027.4     .06       0  1127.4     .05       0  1427.4     .06       0
Bank Sta=318.3,358.82
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,24286   ,600.9,591.2,583.9
XS GIS Cut Line= 3
2175476.55152692 694582.531911732175581.14389599694105.045009428
 2176547.8647265693820.397681895
#Sta/Elev= 30
       0  1509.1     5.5 1508.55    21.9 1503.61    58.7 1496.94    91.4  1493.7
     115 1487.46     199 1447.59   210.2 1440.61   226.6 1438.32   239.3  1430.7
   247.1 1427.49   267.5 1428.44   275.7 1427.31   296.2 1417.57   353.5    1420
   382.2 1419.45   406.8 1416.72     415    1415   447.7 1413.97   457.7 1416.72
   464.1 1422.93   468.2 1425.46   480.5 1427.73   517.1 1426.59   945.3 1428.25
  1234.2 1425.86  1292.6 1427.47  1380.1 1435.42  1463.5 1436.67  1496.6 1440.37
#Mann= 11 ,-1,0
       0      .1       0      40     .07       0     140     .05       0
     240      .1       0   406.8    .045       0   457.7     .05       0
  538.81      .1       0  668.81     .05       0 1058.81     .06       0
 1158.81     .05       0 1468.81     .06       0
Bank Sta=406.8,457.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,23695   ,893.5,920.4,922.9
XS GIS Cut Line= 4
2176162.38233223 694585.435093292176085.34716184694025.654726788
2176334.15159592 693897.64212974 2176553.3617385693828.396823616
#Sta/Elev= 30
       0 1499.32    72.9  1499.3    97.2 1494.78   121.4 1486.47   140.6 1475.27
   165.8 1462.85     182 1456.03   200.9 1443.48   214.3 1441.46   218.3 1439.61
   226.4 1431.68   230.4 1430.38   242.5 1430.79   262.7  1427.2  279.38 1417.39
   286.9 1415.53   319.2 1414.59   323.3 1414.82   331.3 1417.43   359.6 1421.56
   424.2 1422.34     531 1421.45   565.1 1423.93   793.4 1421.52   844.9 1424.35
   869.2  1424.1   926.5  1432.4   964.4 1434.69  1041.3 1436.66  1074.7 1440.97
#Mann= 6 ,-1,0
       0      .1       0     240     .07       0  279.38    .045       0
   331.3     .07       0     340     .05       0 1034.86     .06       0
Bank Sta=279.38,331.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,22775   ,640.6,660.4,668
XS GIS Cut Line= 2
2176874.65630668694459.1872604262176919.20319406693817.154101249
#Sta/Elev= 30
       0 1489.04    66.2 1474.57    90.2 1468.13    99.6 1464.68   138.3 1460.39
   150.4 1458.01   154.4 1456.75   166.4  1450.2   182.4 1444.48   198.5 1441.01
   206.5  1437.6   230.6 1437.14   242.6 1431.36   258.6 1433.22   294.7 1424.51
   326.8 1421.27   378.9 1421.29     412 1419.89   507.2 1418.76   519.3 1419.27
   528.2 1417.94   550.7 1413.97   583.4 1413.76   591.4 1414.78  595.11 1417.91
   607.5 1431.91   619.5 1448.74   623.5 1451.02   631.5 1452.64   643.6 1460.86
#Mann= 5 ,-1,0
       0      .1       0     310     .05       0     510      .1       0
   528.2    .045       0  595.11      .1       0
Bank Sta=528.2,595.11
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,22114   ,714.7,749.7,759.3
XS GIS Cut Line= 2
2177329.60223713694475.077951948 2177603.7861416693905.496664772
#Sta/Elev= 30
       0 1450.92    36.3 1443.61    50.9  1442.1   135.2 1440.47   210.8 1431.44
   224.1 1431.97     233 1434.12   237.4 1434.09   243.1  1432.3   255.1 1426.45
   261.1 1424.98     304 1423.03     372 1423.81   406.1 1419.73   416.9 1416.91
   428.9 1417.31   437.9  1414.1     467 1413.75   479.8 1414.16   481.6 1414.52
   485.8 1417.35   490.4 1421.27   512.6 1435.14   524.8  1438.2   543.7 1449.13
   570.3  1460.3   588.1 1469.91     597 1473.48   610.3 1481.05   632.1 1489.07
#Mann= 4 ,-1,0
       0      .1       0     250     .05       0   428.9    .045       0
   485.8      .1       0
Bank Sta=428.9,485.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,21365   ,530.3,498.4,481.1
XS GIS Cut Line= 2
2177676.30965761694721.0910288882178215.43435854694463.425628718
#Sta/Elev= 30
       0 1474.76    35.3 1463.45    74.8 1448.65   119.8 1432.84   125.8 1432.31
   137.3 1433.76   141.7 1433.39   159.5 1428.61   168.3 1425.02   176.8 1423.83
   203.8 1422.66   239.3 1420.03   272.8 1421.62   310.2 1419.85   314.6 1418.93
   323.5 1415.26   336.8  1415.4   344.8 1414.17   353.8  1414.6   381.1 1414.03
   387.5  1415.4   392.8 1418.84   412.2 1436.66   417.2 1439.84     421 1441.34
   429.9  1442.7   438.8 1447.01   506.8 1469.18     554  1491.4   597.5 1508.18
#Mann= 5 ,-1,0
       0      .1       0     240     .05       0   336.8    .045       0
   387.5     .05       0     410      .1       0
Bank Sta=336.8,387.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,20866   ,565.3,544.1,527.9
XS GIS Cut Line= 3
2178137.10731954695194.0973832492178343.68649569694817.638627665
2178403.42923122694640.456740102
#Sta/Elev= 30
       0 1484.61    14.7 1482.12    23.9 1479.15    51.2  1461.6    60.4 1457.99
    78.6  1446.8    85.4  1441.9    92.3 1435.29     106 1435.28   110.6 1434.01
   119.7 1429.33   129.6 1421.92   135.5 1419.36   151.6 1418.34   164.4 1415.52
     181 1415.07   191.5 1413.24   224.6 1413.09   247.5 1413.09   255.2 1415.08
   264.1 1420.28   294.6 1425.64   352.4 1426.05   425.4 1438.32   446.8 1445.83
   480.3 1460.68   506.1 1468.67   562.7 1496.13   586.1 1502.87   616.4 1508.31
#Mann= 3 ,-1,0
       0      .1       0     181    .045       0   255.2      .1       0
Bank Sta=181,255.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,20322   ,594.9,594.2,599.2
XS GIS Cut Line= 2
2178749.55722665695288.3816144672178751.52686345694649.887561675
#Sta/Elev= 30
       0 1476.87    27.2 1467.53    71.2 1450.26    91.2 1444.03    99.2  1440.3
   111.2  1435.9   119.2 1434.13   127.2 1433.51   135.2  1435.1   143.2 1434.72
   155.2 1429.39   179.2 1416.16  190.38  1413.4   207.2 1412.89   231.2 1413.36
   247.2 1412.88   255.2 1413.82   263.2 1419.65   295.2 1423.26   323.2 1423.31
   355.2  1419.4   367.2 1419.05   421.9 1422.65     450 1426.01   495.2 1435.26
   519.2 1436.47   531.2  1438.1   562.3  1445.7   611.2 1462.59   638.5 1473.88
#Mann= 5 ,-1,0
       0      .1       0  190.38    .045       0   231.2      .1       0
     450     .05       0     550      .1       0
Bank Sta=190.38,231.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,19728   ,602.7,615.3,610.1
XS GIS Cut Line= 2
2179285.41272233695318.9508083762179290.42651523694642.856063705
#Sta/Elev= 30
       0 1509.91    25.8 1502.24    65.8  1493.1    81.8 1488.24   133.8 1465.34
   157.8 1457.71   189.8 1449.03   209.8 1435.14   213.8 1434.34   225.8 1434.99
   249.8 1432.35   274.5 1426.58   297.2 1424.33   329.8 1423.22   385.7 1419.22
   405.8 1419.47   421.8 1417.42   437.8 1417.01   453.8 1412.92   481.8 1414.49
  488.48 1416.86   493.8 1420.76   505.8 1433.45   509.8 1435.93   521.8 1438.99
   537.8 1446.67   549.8 1450.41   569.8 1459.35   605.8 1472.31   676.1 1503.63
#Mann= 3 ,-1,0
       0      .1       0   437.8    .045       0  488.48      .1       0
Bank Sta=437.8,488.48
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,19112   ,625.1,658.3,677.3
XS GIS Cut Line= 4
 2179827.1924551695436.7232649812179823.97105763695156.729813084
2179906.55203629694796.0285781562179844.86735844694575.398547187
#Sta/Elev= 30
       0 1489.87    43.5 1471.17     133 1445.79   259.5 1433.03   267.6  1432.9
   286.5 1435.56   303.2 1429.47   328.8  1428.8   341.1 1426.47   349.3 1423.37
   365.7 1413.77   373.9 1413.04   390.3 1414.58   402.7 1412.59     420 1412.55
   435.5 1412.69  442.69 1414.47   451.9 1417.07   476.5 1415.67   513.5 1415.84
   556.9 1419.33   587.3 1420.26     650 1433.39   683.5 1442.43     707 1451.07
   719.5 1453.63   769.3 1474.59   785.9 1479.34   864.8 1515.92   879.1 1519.42
#Mann= 3 ,-1,0
       0      .1       0   390.3    .045       0  442.69      .1       0
Bank Sta=390.3,442.69
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,18454   ,220.2,267,292.6
XS GIS Cut Line= 3
2180072.08905657695461.4187475422180175.72044412695315.299040152
2180629.92268426695076.914368674
#Sta/Elev= 30
       0 1470.88      14 1465.72    59.1 1454.18    68.9  1452.7    86.3 1447.26
   117.9  1445.5   132.2 1436.03   146.6 1432.99   159.2 1433.47   175.2 1436.06
   197.7 1428.61   237.3 1426.69   297.1 1420.17   337.8  1419.4   428.1 1421.92
   432.9 1421.39   441.9 1417.68   462.5 1415.52   471.4 1412.34   486.2  1412.1
   504.9  1412.5  511.32 1415.51   521.7 1426.83     541 1444.04   550.1 1449.69
   559.1 1453.71   568.2 1459.77   590.7 1471.86     658 1503.39   692.1 1514.79
#Mann= 3 ,-1,0
       0      .1       0   462.5    .045       0  511.32      .1       0
Bank Sta=462.5,511.32
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,18187   ,152.1,156.1,153.5
XS GIS Cut Line= 4
2180128.70495837695503.4946039542180292.13369572695294.096093333
2180781.02101158695543.2649778392180934.27846426 695436.56167492
#Sta/Elev= 30
       0 1475.27    18.2 1467.99    70.7 1452.38   109.5 1446.33   122.7 1440.37
   146.6 1432.27   168.2 1432.15   180.5 1435.99   186.5 1436.29     216 1427.51
   251.6 1421.09   318.5 1420.21   339.3 1416.25   368.9 1414.67   418.3 1413.57
   476.7 1414.46   494.6 1412.51   517.1 1412.06   568.3 1412.83   575.5 1415.64
     598 1431.31   612.9 1435.97   692.2  1448.4   710.1 1448.32   732.6 1452.32
   814.3 1462.02   886.4  1494.2   950.3 1512.11   979.1 1522.72  1001.1 1532.95
#Mann= 3 ,0,0
       0      .1       0   494.6    .045       0   568.3      .1       0
Bank Sta=494.6,568.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,18031   ,280.3,221.8,190.2
XS GIS Cut Line= 4
2180168.89785068695547.7103579932180259.60564591 695415.10407191
2180743.25085399695660.3413755882180951.70511046695513.359323963
#Sta/Elev= 30
       0 1482.53    32.1 1470.68    95.1 1450.96   129.1 1446.83   147.5  1434.1
   153.8  1431.7   210.6 1427.94   282.4 1418.91   372.1 1416.85   434.9 1420.17
   443.8 1418.39   448.4 1414.81   457.3 1411.87   507.8 1411.79   520.1 1412.06
   527.9 1414.47     547 1422.62   554.4 1423.89   587.4 1424.09   607.5 1426.89
   642.9 1424.98   672.6 1426.26   702.9 1428.54   723.1 1434.85   737.4 1436.91
   762.8 1436.78   784.8 1452.49   812.1 1461.24   878.1 1492.08     958 1509.15
#Mann= 3 ,0,0
       0      .1       0   448.4    .045       0   527.9      .1       0
Bank Sta=448.4,527.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,17809   ,604.2,607.8,618.4
XS GIS Cut Line= 3
2180460.56813065695917.7030702622180796.93618228695659.711206227
2180947.12568486 695544.50303237
#Sta/Elev= 30
       0 1501.72    24.7 1492.68    49.9 1479.61   105.4 1446.38   119.9 1436.78
   128.5 1429.69   142.7 1427.47     157 1419.06   165.9 1418.36     181 1415.03
     198 1414.55   211.2 1411.66   251.6 1411.85   256.9 1412.28   261.6 1414.44
   271.1 1420.72   276.8 1422.06   342.4 1424.06   376.7 1426.21   395.2 1428.84
   414.9 1435.31   433.7 1437.48   448.2 1437.29   454.4 1439.78   467.5 1449.98
   473.7 1453.62   498.6 1461.72   566.1  1492.2   579.2 1495.91   613.2 1501.97
#Mann= 3 ,-1,0
       0      .1       0     198    .045       0   261.6      .1       0
Bank Sta=198,261.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,17201   ,539.5,550.6,557
XS GIS Cut Line= 3
2180699.90403631696214.1142656732180964.86927574696264.332529377
 2181380.9244085695953.628491387
#Sta/Elev= 30
       0 1528.45    45.1 1521.08    81.7 1512.83   252.7 1469.28   269.7 1463.74
   325.7 1437.32   333.7 1432.51   342.9 1423.12   358.7 1420.25  364.82 1415.45
     369 1412.52   378.6 1411.38   455.4 1411.54   468.5 1413.07  477.611415.453
   482.9 1417.41   488.6 1418.02   548.4 1416.23   574.4 1420.36     603 1428.85
   623.3 1440.01   628.7 1440.93     643 1440.53   658.2 1448.52   673.2 1451.84
   680.1 1455.71   708.7 1467.73     743 1485.34   754.4 1490.17   788.9 1499.91
#Mann= 3 ,-1,0
       0      .1       0  364.82    .045       0  477.61      .1       0
Bank Sta=364.82,477.61
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,16651   ,684.6,665.6,635.4
XS GIS Cut Line= 3
2180862.22294416696956.522381651  2181058.814583696767.268310961
2181669.32845441696465.252893964
#Sta/Elev= 30
       0 1505.45   114.4 1474.43     131 1471.64   183.6  1469.4   212.5 1464.27
   247.1 1453.43   299.3 1433.85     319 1433.01     371 1423.98   417.2 1419.11
   488.6 1417.73   506.5 1413.47   538.2 1413.78   551.1 1411.02     577 1410.71
   600.2 1411.08  615.19  1413.9   622.5 1417.81   644.8 1421.72   698.4 1426.48
   720.3 1438.51   729.6 1441.96     743 1440.79   756.4 1442.87   777.1 1441.07
   792.1 1442.44   863.5 1460.74   896.5 1467.31   936.1 1480.99     954 1485.02
#Mann= 3 ,-1,0
       0      .1       0   538.2    .045       0  615.19      .1       0
Bank Sta=538.2,615.19
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,15985   ,521.9,524.9,530.1
XS GIS Cut Line= 3
2181535.32301485697414.9986741872181727.02813217696912.073348373
2181866.57437805696782.207115035
#Sta/Elev= 30
       0 1522.78    36.2 1504.09    92.2 1482.12   129.1 1468.76   143.2  1467.7
   151.8  1464.1   177.5 1450.35   198.9 1433.41  221.39 1413.23   231.4 1410.71
   263.1 1411.11   275.9 1413.23   287.2 1413.54   301.6 1417.25   327.3 1417.08
     374 1422.89   445.3 1424.33   481.4 1429.31   516.6 1440.19   552.4 1439.39
   566.6 1448.76   580.7 1450.19   586.4 1452.39   594.9 1459.06   605.4 1471.22
   610.8 1473.99   630.5  1479.7   665.5 1485.78   712.7  1501.1   728.8 1504.02
#Mann= 3 ,-1,0
       0      .1       0  221.39    .045       0   275.9      .1       0
Bank Sta=221.39,275.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,15460   ,565.9,573.3,568.2
XS GIS Cut Line= 3
2182021.86331453697752.0272289912182044.57316187697465.879340666
2182256.10501843697064.100968228
#Sta/Elev= 30
       0 1494.62      59 1478.27   255.6 1436.16   342.1 1426.48   414.4 1422.59
     428 1419.31     437 1415.49   446.1 1414.07   459.6  1410.2   464.1 1410.01
   495.8 1410.66  503.83    1414   509.3 1418.11   512.3 1418.69   535.2 1418.63
   565.6  1412.7   577.2 1413.18   590.7 1420.54   604.1 1429.99     613 1434.32
   617.8 1434.45   626.9 1431.61   631.4 1431.45   639.7 1437.43     654 1453.23
   657.4 1455.05   681.1 1456.34     690  1458.2   715.5 1477.18   741.1    1486
#Mann= 3 ,-1,0
       0      .1       0   446.1    .045       0  503.83      .1       0
Bank Sta=446.1,503.83
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,14887   ,595.6,598.8,596.5
XS GIS Cut Line= 2
2182437.58206505697847.0313314532182769.17896259697271.478893964
#Sta/Elev= 30
       0 1479.75    61.8 1462.83   108.7 1453.81   205.3 1427.59   214.5 1423.01
   225.9  1421.3   228.8  1419.1   233.5 1412.66   237.6 1410.22   269.8 1409.87
   284.4 1410.02     293 1412.66   302.2 1413.06   316.1 1416.39     353 1418.24
   389.8 1414.67   422.2 1414.64   445.5 1416.49   463.1 1426.22   474.8 1429.82
   491.5 1428.44     494 1429.42   501.2 1435.32   509.9 1445.64   539.2 1462.96
   571.5 1467.25     589 1477.02   643.8 1495.32   653.5 1496.77   664.2 1501.23
#Mann= 3 ,-1,0
       0      .1       0   233.5    .045       0     293      .1       0
Bank Sta=233.5,293
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,14288   ,504.1,542.4,624
XS GIS Cut Line= 3
2183006.91994003698031.7596777592183172.62384885 697711.93483606
2183131.53935552697336.818035345
#Sta/Elev= 30
       0 1489.01    98.4 1429.93   106.7 1423.44   133.4 1417.45   151.6 1416.67
  158.03 1412.52   163.1 1410.41   180.7 1409.49   196.6 1413.36   228.2 1410.25
   264.2 1409.56   278.8 1412.56   336.3 1414.43   340.8  1415.6     356 1425.33
     363 1427.22   379.1 1424.91   403.5 1416.55   455.5 1418.68   483.7 1429.36
   523.9 1440.51   548.1 1449.22   600.4 1476.08   604.4 1477.24   616.5  1471.9
   632.6 1472.14   653.2 1491.33   672.8 1497.55   684.9 1499.37   737.6  1520.9
#Mann= 3 ,-1,0
       0      .1       0  158.03    .045       0   278.8      .1       0
#XS Ineff= 2 , 0
                          365.97         1444.85
Permanent Ineff=
       F       F
Bank Sta=158.03,278.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,13746   ,606.3,632.5,663.3
XS GIS Cut Line= 2
2183018.42564075698264.8351344242183827.71212146698277.104835658
#Sta/Elev= 30
       0 1506.29    13.8 1498.16    29.8 1484.73    78.6 1451.97   121.8 1426.31
   141.8  1420.1   165.8 1421.05   197.8 1419.25   225.8 1413.04   245.8 1413.14
   257.8 1409.42   269.8    1409   313.8 1409.48  319.11 1413.16   325.8 1418.49
   333.8 1420.55   361.8 1421.71   425.8 1430.38   433.8 1429.62   441.8 1426.47
   453.8 1428.71   465.8  1427.6   485.8 1435.76   501.8  1435.9   617.8 1448.43
   655.4 1450.07   729.8  1465.8   749.8 1472.68   793.8 1480.71   809.4 1485.22
#Mann= 3 ,-1,0
       0      .1       0   245.8    .045       0  319.11      .1       0
Bank Sta=245.8,319.11
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,13113   ,501.2,506.6,506.8
XS GIS Cut Line= 2
2182925.95754223698668.7789658462183343.99302515699078.173797457
#Sta/Elev= 30
       0 1476.47      16 1471.17    31.1 1469.17    81.5  1454.2   129.1  1430.7
   154.9 1422.17   165.9 1420.77   204.7 1420.41   227.1 1414.18   238.2  1414.5
   249.4 1413.06   267.7 1412.74   277.4 1409.26   297.8 1408.65   322.2 1408.92
   327.8  1410.2   332.1 1412.74   350.2 1426.24   355.4  1427.6   378.1 1430.25
   383.7 1429.72   389.4 1427.81   392.2 1428.09     395 1429.03   400.7 1432.84
   475.1 1460.37   501.4 1467.72     511 1469.53   546.2 1480.75   585.1 1496.37
#Mann= 4 ,-1,0
       0      .1       0   267.7    .045       0   332.1      .1       0
  585.11     .05       0
Bank Sta=267.7,332.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,12607   ,600.5,586.9,572.3
XS GIS Cut Line= 2
2182496.50227878698891.180762599 2182945.4549912699421.428517472
#Sta/Elev= 30
       0 1476.43    28.8 1467.29    83.5 1454.43   149.4 1435.51   172.8 1431.94
   203.8 1429.25   219.7 1423.31   238.5 1424.69     285 1420.88   361.6  1420.2
     373 1418.87     390 1414.25  408.631413.304   416.7 1409.41   424.1 1408.61
   457.6 1408.87     461  1410.4  464.541413.308     478 1423.88     490 1429.44
   500.7 1430.65     511 1428.36   514.9 1429.88   529.1  1446.8   531.9 1449.69
     538 1453.89   552.9 1460.26   563.4 1462.94   615.8  1485.7   694.8 1516.54
#Mann= 4 ,-1,0
       0      .1       0  408.63    .045       0  464.54      .1       0
     630     .05       0
Bank Sta=408.63,464.54
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,12020   ,513.8,477.5,447.2
XS GIS Cut Line= 3
 2182106.3579931699475.4970058682182493.73136676699632.398754918
2182656.94538229699676.925751812
#Sta/Elev= 30
       0 1505.68      18 1491.09    39.5 1478.79    66.7 1465.99   118.5 1444.31
   135.7 1433.08   144.4 1431.56  175.53 1409.64   213.4 1408.56   226.9 1409.62
   239.3 1408.44   248.4  1408.7   257.6 1413.96     273  1415.8   282.2 1420.55
   286.8  1421.5   299.7 1421.12   308.4 1422.67     330 1423.01   377.4 1428.66
   424.6    1430   437.1 1432.47   453.6 1429.15   457.8 1431.07   470.2 1441.89
   474.4 1444.33     491 1446.96   536.6 1460.32   565.6 1470.29   587.1 1479.99
#Mann= 3 ,-1,0
       0      .1       0  175.53    .045       0   226.9      .1       0
Bank Sta=175.53,226.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,11542   ,669.1,635.3,590.8
XS GIS Cut Line= 4
2182049.05780598700227.6197809942182113.50829858700099.922203907
2182412.33333273699921.509684998  2182622.079592699786.437745437
#Sta/Elev= 30
       0 1496.16    20.7 1488.08    83.4 1459.58   137.2 1440.88   178.8  1429.9
     203 1420.78   225.3 1417.97     281 1419.92     291 1412.79   299.9 1408.97
   309.2 1408.06   346.5 1408.44   359.1 1412.76   394.9 1412.76   412.4 1416.85
   439.6 1416.65     449 1418.94   462.9 1425.53   472.3 1428.16   491.1 1429.35
   511.5 1427.89   528.9  1432.6   562.3 1432.96   598.3 1430.62   614.6 1432.14
   628.9 1429.09   643.1 1440.76   647.9 1442.92     705 1453.87   740.5 1462.82
#Mann= 3 ,-1,0
       0      .1       0     291    .045       0   359.1      .1       0
Bank Sta=291,359.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10907   ,466.2,471,471.2
XS GIS Cut Line= 3
2182763.96047332  700563.89342172182760.68847332  700169.0054217
2182857.98597729 700011.01166264
#Sta/Elev= 30
       0 1492.23    26.3 1484.05    86.7  1460.5   158.7 1440.91   174.7 1438.61
   182.7 1432.99   202.7 1415.46  205.98 1411.62   210.7 1408.12   214.7 1407.77
   254.7 1407.65   258.7 1407.65   270.7 1411.88   278.7    1411   294.7 1415.82
   322.7 1419.21   358.7 1421.13   374.7 1426.51   390.7 1430.48   399.4 1429.62
   413.5 1425.13   423.5 1420.59   446.4 1420.25   464.2 1421.73   479.3 1424.51
   493.3 1431.33   530.9 1445.95   551.4 1451.53     563 1453.45   580.5 1458.54
#Mann= 3 ,-1,0
       0      .1       0  205.98    .045       0   270.7      .1       0
#XS Ineff= 2 , 0
                           393.8         1442.71
Permanent Ineff=
       F       F
Bank Sta=205.98,270.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10436   ,654.6,678.1,679.7
XS GIS Cut Line= 3
2183195.11211533700916.549218579 2183232.2917866700243.159895025
2183303.92728919700070.597860584
#Sta/Elev= 30
       0 1477.08    49.1 1465.22    91.5 1452.09   103.5 1455.07   114.3 1455.29
   171.6 1446.94   195.7 1444.66   247.2 1433.56   275.8 1426.03   291.8 1423.37
   347.9 1422.34     408 1412.23   460.1 1412.02   504.1 1416.82   560.2 1415.49
  569.57 1412.39   577.5 1408.92   584.3 1407.75   624.3 1407.79   628.3 1408.21
   635.6 1412.51   652.4 1424.47   672.4 1428.91   685.2  1427.3   689.6 1429.41
   694.2 1435.76   702.5 1440.45   784.8 1468.24   853.3 1498.85   861.3 1500.49
#Mann= 3 ,-1,0
       0      .1       0  569.57    .045       0   635.6      .1       0
Bank Sta=569.57,635.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9758    ,459.8,504.1,509.4
XS GIS Cut Line= 3
2183744.47498792700824.643388985 2183859.2882702 700474.05886231
2183849.61083305700185.852359721
#Sta/Elev= 30
       0 1461.47    16.3 1454.42    37.3 1453.03    75.2 1440.36   126.2 1419.56
     151 1416.18   188.8 1412.83   197.3 1413.05   206.2 1410.36   226.7 1407.76
   281.5 1407.76   285.7 1408.18  289.76 1410.34   298.3 1418.46   302.5 1419.82
   316.4 1420.61     332 1419.92   356.4 1425.21   365.6 1428.98   373.8 1429.07
   385.8 1424.37   389.8 1424.61   397.8 1428.89   417.8 1428.24   429.8 1429.47
   477.8 1443.34   489.9  1445.6   594.4 1476.12   623.4 1487.13   657.3  1502.3
#Mann= 3 ,-1,0
       0      .1       0   206.2    .045       0  289.76      .1       0
#XS Ineff= 2 , 0
                          369.79         1434.14
Permanent Ineff=
       F       F
Bank Sta=206.2,289.76
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9254    ,475.3,483.8,491.3
XS GIS Cut Line= 3
2184009.56538208701035.2794715992184284.54118586 700746.66474698
2184421.17205162700646.224101523
#Sta/Elev= 30
       0 1444.04    14.6 1444.01      26 1440.56    40.1  1437.9    96.6  1430.7
     108 1428.18   125.6 1426.82   183.5 1419.44   190.1 1418.97   206.7 1419.38
   218.3 1418.63     241  1414.1   253.1 1413.89   266.5  1410.2   280.6  1410.6
   290.2 1407.42   334.3 1407.09   340.1 1407.19  346.03 1410.48   351.3 1414.56
   384.1 1427.91   390.9 1429.03   396.6 1428.83   403.1 1427.58     418 1428.92
   425.2 1432.62   436.6 1440.39   439.5 1441.67   517.3 1460.35   568.2 1477.02
#Mann= 3 ,-1,0
       0      .1       0   280.6    .045       0  346.03      .1       0
Bank Sta=280.6,346.03
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8770    ,468,482.4,490.6
XS GIS Cut Line= 2
2184231.00530292701381.4197521572184671.89729947701071.315726345
#Sta/Elev= 30
       0 1450.58    25.9 1445.02    35.7 1440.77    49.8 1440.71    61.3 1437.28
    84.3 1433.81   124.5 1425.19   146.4 1421.43   160.3 1419.66   199.1 1417.63
   221.5 1415.06   242.2 1413.78   256.5 1409.82   270.9 1410.14   282.4  1407.2
   311.1 1406.98   327.2 1407.43   329.1 1408.05  331.24 1410.05   336.9  1416.2
   339.8 1418.28   358.4 1421.04   374.2  1428.9   382.9 1429.75   391.5 1428.26
   408.7  1429.4   428.8  1436.1   441.6 1438.48   466.1 1446.88     539 1469.65
#Mann= 3 ,-1,0
       0      .1       0   270.9    .045       0  331.24      .1       0
Bank Sta=270.9,331.24
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8288    ,595.8,613.4,602.6
XS GIS Cut Line= 3
2184292.64811015701749.0433046452184779.41285713701605.789805507
2184960.37428056701490.700027538
#Sta/Elev= 30
       0 1468.51    32.9 1458.98    82.9 1449.59    91.2 1447.17   103.7 1440.94
   132.9 1440.88   154.1 1436.14   199.6 1429.03   216.3 1428.09   253.6 1423.13
   299.7 1418.71   337.2 1412.49   374.8 1411.25   386.1  1407.5   424.6 1407.06
   431.2 1408.14  435.49 1411.12   441.5 1417.65   445.7 1419.58   483.2 1420.07
     504 1429.55   508.3  1430.5   517.1 1429.69   527.3 1425.01   540.3 1424.07
   588.9 1432.96   627.2 1442.66   664.7 1454.05   673.6 1455.51   721.9 1470.13
#Mann= 3 ,-1,0
       0      .1       0   374.8    .045       0  435.49      .1       0
#XS Ineff= 2 , 0
                          510.03         1433.58
Permanent Ineff=
       F       F
Bank Sta=374.8,435.49
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
