HEC-RAS study FRENCHCK.prj: FRENCHCK

--- FRENCHCK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,78424   ,195.9,201.8,201.4
XS GIS Cut Line= 3
2157390.26476056680788.4271036812157330.23117844680502.509316872
 2157526.9522723680353.664465527
#Sta/Elev= 30
       0 1533.45    11.5 1530.07    19.7 1526.93      45 1515.96    64.6 1508.77
    76.9 1505.03   117.8 1494.24     130 1488.86   146.4 1479.47   150.5 1478.41
   154.5  1478.1   180.2 1478.67   200.4 1478.05   207.2 1476.48   217.3 1475.66
     224 1475.75   228.1 1476.83  230.36 1477.99   232.2 1478.94   236.3 1479.79
   244.5 1480.48   252.6 1481.85   264.9  1483.2   299.6 1483.94   380.5 1483.75
   431.6 1485.05   460.1 1486.72   490.2 1489.88   513.1 1490.95   538.8 1493.05
#Mann= 7 ,-1,0
       0      .1       0   200.4    .045       0  230.36     .05       0
  342.15      .1       0  412.15     .05       0  512.15      .1       0
  532.15     .05       0
Bank Sta=200.4,230.36
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,78222   ,291.1,303.5,310.8
XS GIS Cut Line= 4
2157518.96571488680772.8347703842157538.37327172680628.574617679
2157512.06769665680416.4931381292157568.58325832680367.897821658
#Sta/Elev= 30
       0 1531.67    23.9 1523.78      40  1517.4    52.1 1513.08    80.4 1504.82
   108.6 1497.29   132.8 1489.88   161.1 1482.87   172.1 1481.85   181.2 1479.56
   185.3 1478.83   189.3 1478.54   213.5 1477.97     233 1478.47   240.2 1477.87
   245.7 1476.47   249.7 1476.01   261.7 1475.87   265.9 1475.91   269.9  1476.8
  272.31 1477.85     282 1482.44     286  1483.7   293.4 1484.82   310.2 1485.67
   322.3 1487.42   342.5 1489.59   385.8 1492.78   401.2 1493.59   433.8  1497.3
#Mann= 4 ,-1,0
       0      .1       0  205.56     .05       0   240.2    .045       0
  272.31     .05       0
Bank Sta=240.2,272.31
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,77919   ,319,347.4,362.7
XS GIS Cut Line= 3
2157623.73002372680803.0335044052157756.22352813680592.040512819
2157864.34745847680313.343192497
#Sta/Elev= 30
       0    1529    16.4 1525.55    30.7 1521.08    53.5 1515.44   111.9 1503.83
   158.3  1495.2   172.8 1493.15   219.5 1489.27   265.1 1483.32   286.5 1478.81
   295.1 1477.91     308 1477.53   346.6 1478.89   380.9 1479.03  395.091477.148
   399.7 1476.53   419.5 1475.53   423.8 1476.39  424.761477.149   428.1 1480.08
   432.4 1483.02     441 1486.67   445.3 1488.05   473.9 1492.84   496.8 1494.22
   501.1 1495.77   509.6 1500.25   520.6 1503.56   539.7 1507.99   548.1 1508.72
#Mann= 5 ,-1,0
       0      .1       0      50     .05       0  379.14      .1       0
  395.09    .045       0  424.76      .1       0
Bank Sta=395.09,424.76
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,77571   ,261.2,267.7,271.7
XS GIS Cut Line= 4
2157657.90528779680835.3590344482157833.97545631680749.276159939
 2157938.7458408680729.1815319562158216.28553196680704.909370838
#Sta/Elev= 30
       0 1526.39    42.6 1514.62     105 1504.49   125.9 1500.11   167.3 1490.28
   198.2 1485.72   222.7 1480.08   235.5 1478.09     239 1477.25  241.311476.224
   247.1 1474.54   259.3 1473.99   263.4 1474.18  269.631476.223   279.7 1478.82
   291.9 1483.63     296 1484.04   312.1 1483.53   336.2 1484.18     357 1487.25
   396.3 1490.11   428.6 1491.23   436.6 1492.14   448.7    1495   456.7 1498.94
     489 1507.47   514.5 1511.98     537 1516.98   555.1 1522.61   581.3 1532.25
#Mann= 7 ,-1,0
       0      .1       0     160     .05       0     180      .1       0
  241.31    .045       0  269.63      .1       0  382.67     .06       0
  472.67      .1       0
Bank Sta=241.31,269.63
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,77303   ,359.6,347.5,332.9
XS GIS Cut Line= 3
2157674.84312858680945.5735005782157933.10183888680989.854468044
2158082.99938423 681061.62694757
#Sta/Elev= 30
       0 1520.79     5.4 1520.19     9.5 1519.02    25.7 1512.67    45.8  1506.1
    78.5 1496.67    94.7 1491.39   123.1 1483.51   131.2 1481.74   151.5 1478.39
   160.2 1477.94     184 1478.05   191.4 1477.24  194.281475.876   200.2  1473.6
   207.8  1473.5   216.4 1474.13  221.531475.877   232.3 1481.31   236.7 1482.62
   261.1    1485   274.3 1485.31   283.2 1487.03     292    1488   314.8 1492.18
     332 1495.98   340.8 1498.37   349.7 1499.66   371.9 1504.14   428.2 1520.28
#Mann= 3 ,-1,0
       0      .1       0  194.28    .045       0  221.53      .1       0
Bank Sta=194.28,221.53
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,76956   ,252.5,246.3,240.4
XS GIS Cut Line= 3
2157609.75050325681364.3837826242157882.23614581681221.740417527
2158067.55838615681091.178531956
#Sta/Elev= 30
       0 1545.28    38.9 1529.87    54.6 1525.35    65.9  1521.2      75 1519.86
    78.3 1518.44    97.6 1509.23   124.6 1494.25   142.7 1486.33   147.2 1483.47
  156.26 1475.57   160.8 1473.51   165.3 1473.05   178.8 1473.15  184.79 1475.57
   187.8 1476.93   192.4 1477.75   205.9 1477.75   214.9 1478.59   226.4 1482.17
     233 1483.14   285.7 1484.79   312.2 1484.44   339.3 1487.79   358.9 1488.72
   373.5 1491.83   393.1 1494.83   447.1 1499.99   495.9 1512.41   534.3 1519.01
#Mann= 4 ,-1,0
       0     .05       0      10      .1       0  156.26    .045       0
  184.79      .1       0
Bank Sta=156.26,184.79
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,76710   ,196.4,188.2,181.7
XS GIS Cut Line= 3
2157794.48017527681589.1303050122158021.71787217681358.436734022
  2158167.226062681309.086831227
#Sta/Elev= 30
       0 1522.68    16.8 1518.06    57.7 1502.41   110.7 1484.06  128.111475.353
   134.7 1473.06   150.6 1473.17  157.291475.348   162.4 1477.09     174 1477.53
   201.9 1480.06   210.5 1479.59   230.1 1476.46     247 1476.81   252.6 1477.86
   261.4 1478.11   287.4 1480.53   306.6 1484.08   326.4 1484.47   343.3 1488.66
     352 1490.01   381.3 1491.51   389.8 1493.43   419.3 1504.39   423.6 1505.53
   440.5 1506.93   453.1 1506.75   457.3  1508.3   465.8 1513.59   477.5 1517.12
#Mann= 4 ,-1,0
       0      .1       0  128.11    .045       0  157.29      .1       0
  423.82     .06       0
#XS Ineff= 2 , 0
                           203.1         1488.99
Permanent Ineff=
       F       F
Bank Sta=128.11,157.29
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,76521   ,71.4,71.8,71.3
XS GIS Cut Line= 6
2157942.77581987681860.7573784522157998.28505498681673.866547562
2158035.62456729681620.8285786032158072.23683761681528.138034743
2158082.02457354 681478.111828852158253.71283327681412.637724411
#Sta/Elev= 30
       0 1513.93    12.1 1510.24    45.5 1507.01    70.5 1499.82   141.4 1492.37
     154  1490.1     179 1487.33     233 1482.04  269.151475.086   275.4 1473.41
   285.3 1473.15   293.9 1473.62  296.911475.086   303.1 1478.85   311.1 1480.99
   357.7 1483.06   412.8 1484.41   421.3 1485.82   429.9 1488.76   438.4  1489.9
   455.6 1491.34   464.1 1490.87   468.4 1491.87   472.7 1494.36     477 1495.76
   489.8 1498.36   524.1 1501.66   566.9 1510.01     584 1511.61   594.2 1514.58
#Mann= 8 ,-1,0
       0     .05       0      20     .06       0     120      .1       0
  214.96     .06       0  224.96      .1       0  269.15    .045       0
  296.91      .1       0  470.46     .06       0
Bank Sta=269.15,296.91
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,76450   ,192.3,199.3,204.5
XS GIS Cut Line= 6
2158000.32156908681908.4154270962158055.83080418681721.524596206
2158093.17031649681668.4866272482158129.78258681681575.796083388
2158139.57032274681525.7698774952158311.25858247681460.295773055
#Sta/Elev= 30
       0 1524.63    24.2 1522.65    78.5 1509.26   103.5  1507.1   124.4 1502.58
   161.9  1496.5   216.4 1486.03   244.2 1482.01     272  1480.7   284.9 1476.96
  288.251475.026   293.5 1472.67   297.8 1472.38   310.7 1472.91  318.441475.028
   323.6 1476.52   344.2 1478.23   362.1 1481.71   410.5 1486.72   441.1 1492.24
   468.2 1501.03   488.9 1505.25   496.7 1505.64   509.6 1507.59     531 1506.76
   539.5  1507.6   543.8 1508.64   552.4 1513.64   563.2 1518.47   594.2 1528.62
#Mann= 10 ,-1,0
       0     .05       0      40     .06       0      70     .05       0
     170     .06       0  279.82      .1       0  288.25    .045       0
  318.44     .06       0  389.48      .1       0  490.46     .06       0
  590.46     .05       0
Bank Sta=288.25,318.44
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,76250   ,202.3,204.7,206.4
XS GIS Cut Line= 3
2158103.76519441681936.7060057412158320.45109721681677.250685419
2158388.59221546681538.358718712
#Sta/Elev= 30
       0 1510.89    20.2 1503.84    41.1 1498.97      63 1496.89   103.6 1494.89
   124.5 1493.11   144.2 1490.07   190.2 1480.43   210.1 1479.94   239.1 1476.06
     260 1476.33   266.51474.799   270.4 1473.48     286  1472.6   291.2 1473.34
  293.73  1474.8     301 1480.26   309.5 1483.27   331.4 1485.98   355.9 1486.37
   360.4 1488.86   364.9 1492.62   394.7 1503.23   418.6 1512.82   427.2 1517.42
   436.5 1520.39     445 1524.23   471.8  1533.2   484.3 1536.24   492.7 1537.67
#Mann= 6 ,-1,0
       0     .06       0      10     .05       0   266.5    .045       0
  293.73     .05       0     320      .1       0  478.04     .05       0
Bank Sta=266.5,293.73
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,76046   ,315.6,355,399.9
XS GIS Cut Line= 3
2158187.42147621682095.4161089462158463.43562959681830.168465092
2158621.99695175681734.248652923
#Sta/Elev= 30
       0 1522.82    19.1 1518.62    32.1 1514.62    62.1 1510.17    73.2 1507.66
   101.1 1499.19     112 1496.99   139.7 1493.24   189.7 1489.09     211 1485.59
   222.9 1484.89   234.1 1481.43   250.7 1481.25   272.9 1476.84   287.8 1475.25
   295.1 1475.54   299.51474.456   304.8 1472.83   310.5 1472.36   322.8 1472.98
  328.361474.456   332.3    1476   339.4 1480.45   349.6 1483.48   355.4 1484.46
   398.6 1486.33   439.8 1490.69   500.5 1499.56   519.2 1501.38568.1224 1509.47
#Mann= 7 ,-1,0
       0      .1       0      70     .05       0     170     .06       0
     220     .05       0   299.5    .045       0  328.36     .06       0
     360      .1       0
Bank Sta=299.5,328.36
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,75691   ,324.5,299,262.8
XS GIS Cut Line= 6
2158195.02067729 682104.600902992158449.49880476682119.831225889
2158466.05929796682159.2421861122158485.94742224682276.489223754
2158513.35308286682328.3642242122158691.19154251682297.339543634
#Sta/Elev= 30
       0 1522.33    37.2 1513.45    69.3 1507.74   133.4 1491.88   157.4 1489.71
   169.5 1487.48   185.5 1481.03   193.5 1479.03   217.1 1477.66   233.6 1478.24
   249.6 1474.82   253.6 1474.61   307.8 1473.54   320.1 1474.35   325.41473.395
   328.2 1472.47   331.7 1472.24   348.6 1472.09   358.8 1473.39   427.7 1478.64
   478.2 1480.87   482.3 1481.81   490.9 1484.98   535.1    1490   563.5  1497.1
   587.9 1501.88   591.9 1503.28   604.1 1505.99   628.5 1512.72   655.9 1522.53
#Mann= 3 ,-1,0
       0      .1       0   325.4    .045       0   358.8      .1       0
Bank Sta=325.4,358.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,75392   ,369.3,376.3,383.7
XS GIS Cut Line= 4
2158165.16343967682464.8004297052158312.58365994682434.591368175
2158532.50562787682426.1328309472158706.50982228682353.631083276
#Sta/Elev= 30
       0 1525.65    53.1 1513.92    97.1 1500.18   129.7 1492.32     146 1487.33
   154.1 1485.76   170.1 1481.29   178.1 1478.87  187.08 1472.96   190.1 1471.44
   194.1 1470.72   210.1 1470.59   214.1 1471.16  220.44 1472.96   230.1 1475.95
   258.2 1479.77   298.5 1481.96   302.2 1482.28   310.2 1483.95   318.2 1482.91
   326.2 1482.85     373 1486.49   398.6 1487.17   409.2 1486.19     423 1487.67
   478.5 1497.97   490.3 1499.72   504.5 1502.97   533.2  1510.8559.0727 1520.13
#Mann= 3 ,-1,0
       0      .1       0  187.08    .045       0  220.44      .1       0
Bank Sta=187.08,220.44
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,75015   ,417.6,398.5,367.6
XS GIS Cut Line= 3
2158098.70350431682734.2652585482158397.16903222682826.100805598
2158695.63456013682753.599057927
#Sta/Elev= 30
       0 1529.07    38.7 1517.85    64.3 1511.72    72.7 1509.05    89.9 1504.74
   115.5 1496.57   139.6 1489.98   176.3 1477.21   181.5 1475.83   185.9 1475.41
   194.1    1476   206.6 1475.72   219.2 1476.39   223.3 1475.83  232.891472.541
   235.9 1471.22   244.3 1470.38     261 1471.63  265.341472.538   275.5 1476.77
   281.9 1478.34     367 1481.34   451.2 1486.81   496.5 1490.54   519.5 1493.09
     544 1496.53   562.3 1497.67   577.2 1501.11   599.4 1503.88619.4198 1504.83
#Mann= 3 ,-1,0
       0      .1       0  232.89    .045       0  265.34      .1       0
Bank Sta=232.89,265.34
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,74617   ,241.2,250.1,247.1
XS GIS Cut Line= 4
2158267.74912667683216.3264699932158412.87774421683165.650657191
2158527.40090641683038.6308645192158720.24830093682969.895116848
#Sta/Elev= 30
       0 1535.37    33.8    1525    55.5 1517.66    65.6 1514.64    93.9 1507.71
   100.2 1505.87   110.6 1502.15   119.1 1499.57   140.3 1490.54   159.7 1483.65
   181.9 1478.04   198.9 1475.82  212.611472.053     219 1469.96   224.4 1469.84
   240.5 1470.07   244.2  1470.9  247.091472.053   252.7 1473.38   284.1 1474.71
   319.9 1479.08   355.3 1480.86   389.1  1484.3   424.4 1489.11     472 1496.78
   482.7 1497.83   491.2 1497.91   499.7 1499.67   508.2 1500.69   529.5 1504.12
#Mann= 5 ,-1,0
       0      .1       0      40     .03       0  203.72      .1       0
  212.61    .045       0  247.09      .1       0
Bank Sta=212.61,247.09
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,74367   ,577.3,568.4,534
XS GIS Cut Line= 3
2158384.23428179683444.1851747672158624.77492244683280.795346429
2158823.89508738683101.779317469
#Sta/Elev= 30
       0 1535.14    19.3 1528.43    56.8 1513.37    62.3  1512.3    74.1 1511.34
    85.6 1505.42    97.9 1500.75     116 1495.59   125.9 1491.61   154.7  1482.5
   180.7 1476.25   198.2 1474.78   226.7 1475.32   255.5  1474.6   295.4 1476.36
  310.671471.226   338.2 1469.97  342.461471.228   344.1 1472.04   349.1 1476.97
   352.4 1478.98   358.1 1481.58   363.7 1483.21   403.4 1488.42   431.7 1493.92
   451.5    1497   472.9 1499.81   485.5 1500.76   526.6  1512.8   558.5 1520.98
#Mann= 5 ,-1,0
       0      .1       0      40     .03       0  310.67    .045       0
  342.46     .03       0  370.79      .1       0
Bank Sta=310.67,342.46
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,73798   ,298,304.9,311.9
XS GIS Cut Line= 4
2158814.01175561 683755.905475052158943.83027366683529.728137691
2158878.61422591683355.7937929382158900.40641825683143.678855408
#Sta/Elev= 30
       0 1531.58      30 1524.51    53.4 1517.17    86.2 1506.07    95.4 1500.85
   109.1 1499.71   118.4 1495.58   136.9 1489.46     156 1486.21   173.5 1480.72
   188.2 1479.44   291.3 1476.48   339.6 1473.85   346.8 1472.85  354.641469.248
   359.6 1467.63   368.2 1467.25     381 1467.52  387.87 1469.25   394.5 1471.53
   410.9 1473.78     428 1475.02   489.4  1485.1   505.5 1486.82   541.5 1493.01
   581.9 1497.35     606  1501.7     614 1501.93   650.2 1506.73   659.8  1507.3
#Mann= 3 ,-1,0
       0     .05       0  354.64    .045       0  387.87      .1       0
Bank Sta=354.64,387.87
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,73493   ,426,411.2,399.5
XS GIS Cut Line= 3
2158895.84964718683804.3026402792159179.48961619683431.458416523
2159208.28539589683120.581051626
#Sta/Elev= 30
       0 1523.52      19  1520.8    39.1 1516.66    74.3 1506.85    86.4 1502.92
    94.4 1498.93   108.1  1497.3   130.9 1489.57   145.2 1487.28     188 1477.95
     205 1477.03   222.3 1474.74     285 1471.59   470.8  1473.5     531 1471.41
     535 1471.12  540.731468.445   543.1 1467.14   547.1 1466.63   563.2 1467.34
  567.071468.448   575.2 1474.72   591.3 1481.64   635.5 1491.31   651.5 1491.15
   659.6 1492.22   671.6 1495.69   695.5 1497.52   731.9 1501.84   780.7 1511.36
#Mann= 6 ,-1,0
       0     .05       0  540.73    .045       0  567.07     .05       0
  578.47      .1       0  678.47     .06       0  778.47      .1       0
#XS Ineff= 2 , 0
          469.63 1478.64
Permanent Ineff=
       F       F
Bank Sta=540.73,567.07
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,73082   ,156.8,164.4,167.1
XS GIS Cut Line= 3
2159640.06096794683758.100705785  2159409.595407 683404.38532444
2159414.23040124683232.023055319
#Sta/Elev= 30
       0 1546.59    29.7  1535.6    67.1 1523.73   119.1 1500.94   146.3 1491.14
   156.7 1488.34   163.4 1485.39   168.2 1484.47   182.7 1484.78   191.4 1483.84
   202.9 1478.49   220.3 1473.52     235 1466.58   239.8 1465.92   249.2 1467.56
   257.9 1467.45   269.4 1465.21   278.1 1465.32  284.17 1467.41   292.5 1471.76
   297.1 1472.43   373.5 1472.88     414 1476.92   429.4 1479.39   449.4    1479
   477.4 1483.34   517.4 1486.62   557.4 1492.83   569.4 1493.52   594.6 1499.65
#Mann= 8 ,-1,0
       0     .06       0      50      .1       0     110     .06       0
     170      .1       0   257.9    .045       0  284.17      .1       0
     400     .07       0  502.17     .06       0
Bank Sta=257.9,284.17
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72918   ,62.7,62.8,63.1
XS GIS Cut Line= 6
2159706.53061173683725.9595794622159633.69509468683499.790216518
2159635.13167689683476.1118079652159610.47011401683393.040168941
2159577.89794047683360.6431444182159501.77733618683125.114824389
#Sta/Elev= 30
       0 1550.46    30.2 1539.83    68.1 1528.52   116.9 1508.79   147.9 1498.01
   161.4 1494.32   198.3 1486.24   210.9 1478.77   236.1 1476.61   252.2 1468.48
   260.3 1466.86  270.081466.667   289.4 1464.88   293.6 1465.24  297.761466.667
   301.9 1469.07   306.1 1469.73   359.1 1470.14   377.8 1472.43   393.2 1472.49
   410.2 1478.06   442.5 1486.56   460.6 1490.06   493.4 1494.93   528.3 1502.68
   544.7 1504.34   561.5 1508.37   590.9 1512.44   624.6 1519.58   641.4  1524.1
#Mann= 8 ,-1,0
       0      .1       0     110     .06       0  270.08    .045       0
  297.76     .06       0  321.33      .1       0  387.99     .06       0
  433.93      .1       0  641.45     .05       0
Bank Sta=270.08,297.76
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72855   ,198.2,188.6,178.2
XS GIS Cut Line= 6
 2159748.7662212683715.3268484512159693.33112359683482.632328216
2159694.76770581683458.9539196632159670.10614293683375.882280639
2159637.53396939683343.4852561162159533.13768351683106.869409872
#Sta/Elev= 30
       0 1552.22    14.5 1548.32    42.1 1539.41    63.9 1533.54    85.3 1526.49
   129.7  1507.8   154.3 1498.56     179 1490.49   192.4 1487.08   231.4 1479.37
   244.7 1475.86   256.7 1473.52     269 1472.61   273.1 1471.06  281.141466.596
   285.6 1464.42   289.8 1464.22   302.3  1464.3  311.011466.596     319 1468.65
   398.9 1471.85   418.7 1476.12   441.8 1483.53   467.8 1489.95   507.5 1495.44
   555.4 1507.39   577.3  1509.4   603.5 1513.01   625.4 1519.85   654.1  1525.1
#Mann= 8 ,-1,0
       0      .1       0     200     .06       0  281.14    .045       0
  311.01     .06       0  312.93      .1       0  415.52     .06       0
  525.52      .1       0  635.52     .05       0
Bank Sta=281.14,311.01
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72666   ,273.7,283.2,291.1
XS GIS Cut Line= 3
2159921.94109054683492.5957841072159854.27279272683330.675214309
2159586.01632633683069.668922693
#Sta/Elev= 30
       0 1503.91      34  1497.3   107.7 1486.17   133.8 1480.22   155.4 1476.13
   160.2 1475.56   175.5 1475.87   183.7 1472.41     195 1468.61   200.7 1467.37
  211.121466.418   217.6 1464.11   223.1 1464.01   237.4 1464.34   240.3 1464.86
  242.871466.417   245.9  1468.2     251 1469.17   285.5 1468.11   298.1  1469.5
   333.6 1476.99   384.5 1489.99     427 1497.19     463 1507.36     475 1509.57
   502.1 1513.19   513.3  1515.7   524.4 1519.06   541.2 1522.47549.7719 1523.57
#Mann= 7 ,-1,0
       0      .1       0      80     .06       0  185.49     .05       0
  211.12    .045       0  242.87     .05       0  285.49     .06       0
  325.49      .1       0
Bank Sta=211.12,242.87
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72383   ,355.7,380.1,405.9
XS GIS Cut Line= 3
2160115.27908433683307.7163275462160007.73482529683068.460560232
2159989.60938837682884.789466132
#Sta/Elev= 30
       0 1499.07    20.3 1495.35    37.5 1490.66    46.6 1489.81    49.7 1489.04
      73 1481.28    94.9 1474.89     130  1470.7   143.1 1467.49   160.7 1468.26
   164.6 1467.68  168.761466.149   173.4 1465.01   176.7 1464.75   202.7 1464.14
   208.9 1464.86  211.411466.146   217.7 1469.03   222.1 1470.38   225.1  1470.8
     244  1472.2   273.7 1473.25   293.2 1474.47   301.8 1475.38   312.5 1477.34
   325.9 1481.25   366.1 1496.31   382.4 1501.97   418.4 1512.14446.8781 1522.19
#Mann= 4 ,-1,0
       0     .06       0      90      .1       0  168.76    .045       0
  211.41      .1       0
Bank Sta=168.76,211.41
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72003   ,297.1,302.4,309.8
XS GIS Cut Line= 3
 2160186.9509017683307.7628337342160207.61430656683187.229688431
 2160419.8955175682921.844047787
#Sta/Elev= 30
       0 1501.68    18.9 1498.28    27.5 1494.92      31 1494.47    43.2 1494.88
    67.6 1486.17      96 1477.83   120.3 1472.74   141.2 1469.37   160.8  1468.9
   176.1 1469.95   201.8 1470.56   247.9 1469.97   273.5 1470.61   296.1 1470.02
   309.1 1466.75   324.7 1468.13  331.55 1465.64   334.9 1464.46   340.1 1463.89
   365.7 1464.15  369.761465.642   372.9 1468.17     381 1477.82   388.8 1485.99
   392.1 1488.82   398.5 1492.84   411.8 1498.43     440 1508.94   462.1 1516.08
#Mann= 5 ,-1,0
       0      .1       0      90     .06       0  202.29      .1       0
  331.55    .045       0  369.76      .1       0
#XS Ineff= 2 , 0
           269.3  1479.3
Permanent Ineff=
       F       F
Bank Sta=331.55,369.76
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71701   ,359.4,348.9,331.1
XS GIS Cut Line= 3
2160255.98693537683365.280921933 2160393.7172363683226.872815411
2160527.03624251683039.014505163
#Sta/Elev= 30
       0  1506.6    22.8 1499.46    31.3 1495.17    34.1 1494.51      40  1494.4
    45.5 1492.98      57 1485.87    79.7 1474.24    90.7 1467.08   94.991464.979
    99.2 1463.65   104.9 1463.19   119.4 1463.46     1261464.978   130.7  1466.2
     142 1466.25   164.7 1469.82   212.6 1470.26   235.5 1471.11   258.5 1470.92
   289.4 1473.25   315.1 1476.82   324.5 1479.27   334.7 1480.88   344.5 1483.71
   358.9 1483.24   388.6 1486.23   396.2 1488.05   413.8 1493.77   425.6 1498.86
#Mann= 5 ,-1,0
       0      .1       0      60     .06       0   94.99    .045       0
     126     .06       0  195.26      .1       0
Bank Sta=94.99,126
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71352   ,266,257.4,241.3
XS GIS Cut Line= 4
2160479.21318098683591.5732781832160606.55324612683449.990271972
2160616.74950572683214.6724180352160663.57441417683095.696916227
#Sta/Elev= 30
       0 1507.85    27.9 1502.47    85.2 1487.77   100.1 1482.96   112.8 1477.18
   118.5 1475.78   141.2  1474.5   186.5 1473.52   251.3 1468.72   271.3 1468.56
   291.3 1467.57   307.3 1468.15   319.4 1467.97   331.4 1467.31   335.4 1466.59
   339.4  1464.7   343.4 1463.48   355.4 1463.72   363.4 1462.38   367.4 1462.28
   387.4 1462.65   391.4  1462.9  394.95  1463.7   407.2 1467.16   415.4 1471.92
   436.2 1475.06   513.5 1494.26   530.7 1500.53   547.9 1507.53   553.8 1510.32
#Mann= 5 ,-1,0
       0      .1       0     100     .06       0  220.42      .1       0
   355.4    .045       0  394.95      .1       0
Bank Sta=355.4,394.95
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71094   ,418.5,426.8,413.6
XS GIS Cut Line= 2
2160942.88467321683550.9651168482160811.57873785 683148.02222698
#Sta/Elev= 30
       0 1509.95    22.9    1504    81.8 1483.24    98.6  1478.9   115.5 1476.58
   157.5 1473.25   170.2 1471.53   178.6 1471.19   182.8 1470.63   193.9 1467.34
   203.8  1465.2   237.5 1465.86  241.611464.634   245.9 1462.91   250.1 1462.26
   258.5 1462.23   292.2 1462.86   296.4 1463.49  299.661464.633   304.8    1466
     309 1466.32   321.6 1466.21   334.2 1465.42   338.4 1465.58   341.8 1466.35
   355.3 1472.42   380.5 1482.14   393.1 1483.82   401.5 1487.92   423.8 1494.52
#Mann= 5 ,-1,0
       0      .1       0      30     .06       0     140      .1       0
  241.61    .045       0  299.66      .1       0
Bank Sta=241.61,299.66
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,70668   ,185.1,194.1,202
XS GIS Cut Line= 4
2161267.12664736683361.7810093162161101.75047259683056.906219759
 2161100.0944902683033.4180488582160950.62582213682990.147556872
#Sta/Elev= 30
       0 1506.62    32.5 1496.74    46.2 1494.05    82.3 1484.75     119 1477.75
     156  1472.9   169.1 1471.72   185.5 1471.27   229.8 1467.72   247.5  1464.2
   260.1 1464.77  268.191463.939   282.8 1462.26  294.491463.938   303.5  1465.2
   319.2 1464.87     333 1467.92   341.9 1468.72   370.4  1469.2   386.7 1468.76
   395.3 1469.96   403.6 1472.69   428.6 1482.88   461.9 1491.02   478.6  1497.7
   486.9 1498.93     490 1499.99   495.2 1502.66   507.7 1507.11     526 1511.61
#Mann= 3 ,-1,0
       0      .1       0  268.19    .045       0  294.49      .1       0
Bank Sta=268.19,294.49
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,70474   ,290.6,287.1,283
XS GIS Cut Line= 4
2161445.26553457683326.8243815992161320.82164091683163.627745818
2161309.58828017682956.3545074192161300.68226656   682691.023761
#Sta/Elev= 30
       0 1534.87    27.2 1530.15    47.6  1525.1    62.4 1520.02   113.9 1498.23
   130.4 1492.27   147.9 1487.59   211.7 1475.19   219.7 1472.75   235.7 1465.29
   239.7 1464.45   255.8 1465.52   283.8 1464.76   291.8 1464.19  296.33 1462.66
   303.8 1461.17   319.8 1461.16   327.9 1461.33  330.85 1462.66   335.9 1465.95
   339.9 1466.73     484 1469.95     508  1468.6     528  1470.6   540.1 1473.67
   555.4 1479.36   592.1 1488.84   616.1 1496.35   652.1 1504.53   678.3 1512.58
#Mann= 3 ,-1,0
       0      .1       0  296.33    .045       0  330.85      .1       0
Bank Sta=296.33,330.85
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,70186   ,428,462.1,476.2
XS GIS Cut Line= 4
2161552.79099965683299.9475063832161609.76387591683116.497498102
2161548.75847206682860.1945055662161554.05424853682669.177624612
#Sta/Elev= 30
       0 1537.11    36.4 1530.99    57.3  1525.2   145.5 1490.66     183 1474.76
   192.1 1471.53   212.8 1466.04   216.1 1464.72  222.141460.664   228.4 1459.37
     249 1459.82  255.61 1460.69   265.4 1461.41   273.6 1460.65     286 1462.99
   310.6 1462.26   322.4 1463.77   347.6  1463.9   364.1 1462.61   429.9  1462.3
     434 1463.03   446.3 1468.78   462.6 1473.68   486.6 1479.03   494.6 1479.39
   506.6  1482.8   537.5 1488.82   574.6 1497.25   623.9 1511.65   646.6 1519.45
#Mann= 3 ,-1,0
       0      .1       0  222.14    .045       0  255.61      .1       0
Bank Sta=222.14,255.61
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,69724   ,405.3,422.7,420.7
XS GIS Cut Line= 2
2161704.84487108683364.0301296152162010.17886693 682993.36212927
#Sta/Elev= 30
       0 1522.16    50.3  1504.9    92.5 1491.51   103.8 1486.63   112.4 1484.59
     154 1467.33   169.5 1461.87  175.981458.432   180.6 1457.18   205.8 1457.01
   216.2 1457.27  220.23 1458.43   226.5 1459.77   231.7 1460.13   256.9 1460.58
   265.8 1460.06   277.2 1461.22   285.7 1461.17   291.4  1461.8   311.3    1468
   349.3 1474.11   385.2 1483.15   397.6 1486.83   407.9 1488.31   413.1 1489.77
   418.3 1492.03   427.8 1493.18   439.2 1497.69   456.2 1503.35   480.2 1508.76
#Mann= 3 ,-1,0
       0      .1       0  175.98    .045       0  220.23      .1       0
Bank Sta=175.98,220.23
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,69302   ,355.8,350.4,346.8
XS GIS Cut Line= 3
2161940.10162047683559.7673795292162081.93874905683463.286122714
2162336.72312478683190.254619436
#Sta/Elev= 30
       0 1514.27      48 1500.46    68.6 1496.21    77.5 1493.27      92 1491.36
     120 1484.49   154.9 1473.56   168.2  1471.5   180.7 1468.17   205.7 1463.94
  222.211456.718   225.6 1455.96   239.3 1455.47   256.9 1455.73  263.741456.717
     268 1457.74   273.7 1458.13   294.8  1458.3   322.1 1456.92     339  1457.7
   344.4 1459.63   365.9 1472.55   381.2 1479.57     418 1493.21     448 1502.25
   457.6 1505.82   474.6 1507.88   480.8 1511.34   508.2 1520.55     545 1535.23
#Mann= 3 ,-1,0
       0      .1       0  222.21    .045       0  263.74      .1       0
Bank Sta=222.21,263.74
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,68951   ,292.4,292.7,300
XS GIS Cut Line= 3
 2162260.6731203 683838.230125822162372.16750121683630.322248533
2162531.29538022683391.117120989
#Sta/Elev= 30
       0 1506.79      27 1501.34    60.2 1496.29    75.1 1491.85   123.7 1482.32
     157 1476.44   173.7 1475.63   182.7 1471.18   187.3 1470.15     210 1467.22
   219.1 1466.81   245.4 1462.97   270.9 1460.88   280.5 1456.02  286.021454.553
   291.6 1453.84     319 1453.47   333.4  1453.7  339.791454.552   347.8 1456.28
   376.6 1457.68   381.4 1459.88   395.8 1469.37   400.6 1471.81     407 1473.64
   448.7 1489.02   458.9 1490.31   472.7 1495.13   510.4  1503.2   523.2 1507.11
#Mann= 3 ,-1,0
       0      .1       0  286.02    .045       0  339.79      .1       0
Bank Sta=286.02,339.79
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,68659   ,534.9,537.6,524.4
XS GIS Cut Line= 3
2162477.85494222683931.6092211472162619.55574664683758.034247843
2162582.48113181683537.916432693
#Sta/Elev= 30
       0 1507.51     8.3  1505.3    18.6 1501.43    40.3 1494.81    70.3 1488.07
    80.1 1485.38    90.9 1483.53     100 1480.61   104.9 1478.62   108.6 1476.55
   122.8 1465.59   131.3 1459.88   137.4 1456.89   146.9 1453.38     154 1452.11
   168.4 1451.84   180.8 1452.03   186.91453.372   193.8 1457.13   196.7 1457.86
   209.7  1458.8   261.4 1459.49   306.1 1459.04   321.5 1458.33   334.5 1458.57
   399.4 1468.43   411.5 1470.63   419.6 1471.55   435.9 1475.22   447.3 1478.65
#Mann= 3 ,-1,0
       0      .1       0   146.9    .045       0   186.9      .1       0
Bank Sta=146.9,186.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,68121   ,326.3,362.4,369.7
XS GIS Cut Line= 2
2162917.80962289  684141.01861152163123.09974491683641.049365382
#Sta/Elev= 30
       0 1498.88    25.8 1492.13    58.9 1485.56    66.1 1483.42    77.7 1482.04
   133.9 1472.22   172.8 1469.06   216.8  1464.3     250 1462.41   285.2 1459.51
   311.2 1456.99   324.1  1454.5   345.8 1454.35  354.311451.517   363.4 1450.13
     389 1450.25  396.151451.518   397.6 1452.21   416.9 1468.27   427.9 1473.25
   436.6    1480   458.4 1494.06   462.5 1496.13   471.1 1499.59   484.1 1503.56
   497.1 1506.29   510.5 1510.26   519.7 1511.33   531.7 1516.48   540.5    1519
#Mann= 3 ,-1,0
       0      .1       0  354.31    .045       0  396.15      .1       0
Bank Sta=354.31,396.15
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,67758   ,312.8,327,321.4
XS GIS Cut Line= 4
2163140.20938363684302.3722006422163266.97511649684021.161513512
2163398.85987362683949.4386092622163573.91160246683766.137930979
#Sta/Elev= 30
       0 1527.47    49.6 1508.03    85.6 1498.51   109.8 1491.29   154.9 1473.88
   184.8 1461.48   194.4 1458.58   206.5 1457.72     270 1456.57   312.3 1456.53
   332.6 1452.57   350.8  1453.5  365.181450.029     369 1449.33   400.9  1448.4
   406.7 1448.76  411.821450.029   419.1 1453.79   428.2 1460.79   433.2 1463.65
   466.3 1475.36   486.6  1479.6   514.3 1487.53   527.6 1488.78   536.1 1491.96
   564.4 1500.11   591.7 1508.97   628.5 1517.76   674.7  1533.8     712 1548.59
#Mann= 3 ,-1,0
       0      .1       0  365.18    .045       0  411.82      .1       0
Bank Sta=365.18,411.82
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,67432   ,443.5,448,444.1
XS GIS Cut Line= 4
2163186.19561875684433.7846228872163358.49669797 684306.73749555
2163500.98374629684226.8948765962163755.95737642684153.207124439
#Sta/Elev= 30
       0 1544.22      28 1540.36    52.2 1534.19      77 1523.08    91.9 1512.89
   101.9 1509.72   111.8 1504.89   129.1  1498.7   141.6 1492.75   181.4 1470.99
   201.3 1456.67   206.2 1455.57   225.2 1455.41   229.8 1453.87  237.781448.263
   243.5 1446.67   257.3 1446.83  265.14 1448.26   280.2 1449.71   293.9 1448.75
   321.5 1449.16   339.5 1455.66   356.4 1459.15   430.7 1469.03   468.2 1476.62
   505.6 1482.33   551.4 1493.03   568.1 1495.58   622.2 1511.31   642.8 1516.01
#Mann= 3 ,-1,0
       0      .1       0  237.78    .045       0  265.14      .1       0
Bank Sta=237.78,265.14
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,66983   ,421.7,448.2,476.6
XS GIS Cut Line= 3
2163377.66986969684720.9278759062163577.98224922684665.776119954
2163929.54074733684471.185116503
#Sta/Elev= 30
       0 1520.16    19.2 1513.52    60.4 1496.17    89.7 1486.75      98 1483.14
   110.5 1482.05   148.2  1468.9     181 1458.27   189.3  1456.8   205.9 1455.13
   214.8 1454.75   233.1 1451.48   262.8 1450.61   283.4 1447.59  286.261446.673
   291.6 1444.87   295.2 1444.65   310.9 1445.09  321.291446.673   327.5 1448.24
   338.3 1448.51   342.3 1449.36   371.7 1459.57   397.7 1471.08     416 1480.82
     448 1493.57   466.3 1498.81   495.3 1505.22   539.4 1516.49   609.6 1540.82
#Mann= 3 ,-1,0
       0      .1       0  286.26    .045       0  321.29      .1       0
Bank Sta=286.26,321.29
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,66535   ,405.4,404.4,402.8
XS GIS Cut Line= 4
 2163354.4688231684874.6678523052163543.77894202684931.058100494
2163726.86024819 685105.112997932163856.46687901685127.955880391
#Sta/Elev= 30
       0 1527.85    38.8 1516.25    47.7 1512.77    51.9 1509.21      56 1504.15
    60.2 1500.85      88 1490.77    97.8 1485.43   114.5  1485.7   118.6 1484.75
   156.2 1473.82   185.4 1462.77   209.1 1455.85   238.9 1450.73   255.9 1449.81
   292.7 1450.51   322.5 1448.45   340.8 1449.14   346.4  1447.9  349.831446.023
   357.4 1443.73   369.1 1443.59   377.6 1444.06  383.021446.022     403 1454.89
   418.8 1459.24   463.7 1467.61     479 1468.72   506.6 1473.56   581.7 1491.78
#Mann= 3 ,-1,0
       0      .1       0  349.83    .045       0  383.02      .1       0
Bank Sta=349.83,383.02
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,66131   ,191,171.9,152.7
XS GIS Cut Line= 3
2163121.30062565685113.594498447 2163451.2242475685394.551749396
2163555.26113652685440.591749051
#Sta/Elev= 30
       0 1517.35    11.7 1514.44    40.6 1510.18      84 1501.38   110.4 1495.27
   147.4 1484.39   213.9 1467.35     240  1458.1   251.4 1452.81   265.6 1448.93
   271.7 1448.06   295.5 1447.81   332.5 1448.13   345.3 1448.86   350.8 1448.28
  360.041445.413   364.9 1443.44   369.5 1443.21   382.1 1443.43  388.581445.412
   396.2  1447.9   403.1 1452.79   406.5  1454.6     416 1455.62   424.1 1457.25
   439.1 1457.15   449.7 1463.23   466.4 1470.03   511.9 1481.79   547.1 1493.25
#Mann= 8 ,-1,0
       0     .05       0      10      .1       0     130     .05       0
     140      .1       0  360.04    .045       0  388.58      .1       0
     400     .06       0  433.34      .1       0
Bank Sta=360.04,388.58
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65959   ,41.4,41.5,41.5
XS GIS Cut Line= 5
 2163029.4034434685663.7361631272163159.98977495685518.180370462
2163248.29194737685500.4047884292163388.23601762685422.853998524
2163545.27170711685457.027663299
#Sta/Elev= 30
       0 1496.19    15.1 1493.65    32.1 1489.31      70 1477.59      88 1471.19
   110.9 1465.33   116.3 1464.15     127  1463.3   143.2 1460.92   148.5 1459.29
   153.9 1455.66   159.3 1454.53   240.7 1449.94   299.2 1448.72   323.2 1446.75
  329.671444.815   335.8 1442.92   343.8 1442.84   349.5 1443.44  352.581444.816
   358.5 1447.06   363.2 1447.61     409 1450.43   422.7  1452.2   471.1 1453.24
   475.4 1454.43   484.5 1460.13   491.2 1463.23   568.6 1481.79   606.3 1495.28
#Mann= 7 ,-1,0
       0      .1       0  265.55     .06       0  305.62     .05       0
  329.67    .045       0  352.58     .05       0  375.62     .06       0
  485.62      .1       0
Bank Sta=329.67,352.58
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65918   ,232.1,225.5,221.9
XS GIS Cut Line= 5
2163042.62812237685703.6197480162163173.21445392685558.063955351
2163261.51662634685540.2883733182163401.46069659685462.737583413
2163558.49638609685496.911248188
#Sta/Elev= 30
       0 1500.21    40.9 1493.31      51 1490.98    62.4 1487.84    94.6 1475.18
   116.1 1467.78   130.3 1463.78   148.4 1460.12   164.3 1458.93     188 1453.67
   195.5 1452.57   227.1 1451.15   311.5 1449.29   328.1 1447.58  336.361444.491
   339.9 1443.15   345.8 1442.64   352.7 1442.94   357.61444.489   366.4 1448.38
   416.4 1451.28   440.6 1458.58   493.4 1470.39   526.2 1476.63   542.5 1481.48
   551.2 1485.06     571 1494.62   584.4 1502.55   587.8 1503.79   606.3 1507.36
#Mann= 5 ,-1,0
       0      .1       0  255.55     .06       0  336.36    .045       0
   357.6     .06       0  475.62      .1       0
Bank Sta=336.36,357.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65692   ,321.6,318.1,318.3
XS GIS Cut Line= 3
2163272.56870073685842.700446207 2163550.4920668685586.259079445
2163655.21681344685552.693455524
#Sta/Elev= 30
       0 1486.51     8.1 1482.66    19.9 1479.79    37.6 1472.36    65.9 1462.87
    77.2 1461.36   108.3 1459.35   124.6 1455.84   135.5 1454.63   145.2 1451.98
   162.1 1444.33   173.6 1443.39   184.5 1441.61   195.4 1441.57   200.8 1441.92
   204.6 1443.39   210.3 1445.73   221.6 1447.91     277 1452.44   291.3 1455.77
   309.3 1461.25   332.6 1465.69   362.1 1476.39   371.6 1481.11   392.5 1487.78
   405.1 1495.28   413.5 1501.62   418.5  1503.8   451.3 1510.46488.1305 1514.09
#Mann= 3 ,-1,0
       0      .1       0   173.6    .045       0   204.6      .1       0
Bank Sta=173.6,204.6
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65374   ,287.6,293.3,294.6
XS GIS Cut Line= 2
2163375.95082241686101.8270628832163832.44330774685723.206825046
#Sta/Elev= 30
       0 1514.79    37.5 1506.03    88.7 1491.25   148.3 1472.98   161.4 1469.44
   182.4 1465.02   232.8 1456.49   264.2 1452.82   276.2 1452.28   296.5 1447.44
   301.7 1446.69   317.3 1446.89   333.1 1445.87   345.6 1446.84   369.9  1447.2
   378.4 1446.85   400.4 1444.75  404.731443.165   409.7 1441.46     416 1440.99
     421 1441.39  424.331443.165   438.1 1452.97   443.8 1455.72     468 1463.66
   502.3 1473.35   511.9 1477.06   540.8 1486.22   577.1 1498.73   593.1 1503.42
#Mann= 3 ,-1,0
       0      .1       0  404.73    .045       0  424.33      .1       0
Bank Sta=404.73,424.33
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65081   ,511.1,511.6,491.6
XS GIS Cut Line= 3
     2163376.662      686233.1972163701.07650362686145.362374698
2164036.82287832 685996.52874422
#Sta/Elev= 30
       0 1540.76    16.1 1535.39    40.9 1523.99    57.5 1517.99    78.2 1512.79
   111.4 1506.35   182.2 1487.91   205.1 1480.97   235.7  1470.5   260.6 1463.74
   314.4 1454.62   335.5 1451.74   356.8 1451.24   370.1 1449.57   408.3 1449.21
   413.9 1446.91  418.511442.846   422.6 1440.97   426.5  1440.6   448.9 1440.32
   453.2 1440.93  456.071442.847   462.9 1445.93   523.3 1445.91   569.7 1462.57
   635.7 1478.25   658.9 1484.99   672.1 1491.36   689.5 1492.32   703.4 1497.15
#Mann= 3 ,-1,0
       0      .1       0  418.51    .045       0  456.07      .1       0
Bank Sta=418.51,456.07
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,64569   ,277.6,284.2,292.8
XS GIS Cut Line= 4
2163430.64487867686540.2533822892163740.88175457686569.918626337
2163917.02868003686418.6865527042164070.43650362686399.845984127
#Sta/Elev= 30
       0 1494.18    20.6 1492.57    45.7 1488.09    77.9 1485.49   142.9    1476
   190.4 1466.15   238.6 1457.89   254.7 1454.23   298.4 1453.44   326.5 1450.85
   337.3 1450.96   363.4 1447.24   368.1 1445.68  371.851442.627   374.2 1440.77
   376.9 1440.29   396.8 1439.94   408.1 1440.25  413.861442.625   417.2 1444.96
   421.4 1445.53   447.8 1443.93   476.2 1445.69     547 1459.22   571.2 1462.68
   599.4 1471.54   607.4 1479.79   611.5 1481.22   651.8 1492.46   698.4 1500.31
#Mann= 3 ,-1,0
       0      .1       0  371.85    .045       0  413.86      .1       0
Bank Sta=371.85,413.86
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,64285   ,446.2,422.1,372
XS GIS Cut Line= 3
2163574.00851052686896.1253705572163974.76155317686736.888667482
2164021.09000552686675.185725933
#Sta/Elev= 30
       0 1499.08    15.2 1494.61    37.8 1486.99    49.7 1483.57      97 1472.54
     153 1457.69   204.6 1450.19   225.7 1448.14   260.6 1446.53   286.4 1443.84
   320.8 1444.72   338.1 1443.86  340.831442.512   346.7 1439.84   354.6  1439.6
   368.2 1439.64   372.5 1440.22  377.881442.512   385.4 1446.97   389.7 1448.77
   406.9 1451.08   415.5 1451.61   419.8 1452.51   431.2 1456.83   454.9 1467.39
   480.9 1478.23   485.9 1479.59   494.9 1481.11   500.9 1482.99   508.4 1484.52
#Mann= 3 ,-1,0
       0      .1       0  340.83    .045       0  377.88      .1       0
Bank Sta=340.83,377.88
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,63863   ,483.4,480.3,450.3
XS GIS Cut Line= 3
2164204.77373318687103.1358731452164203.45049189686948.314373318
2164073.80612927686658.265602183
#Sta/Elev= 30
       0  1490.3      22 1490.25      34 1489.39      54 1486.68    77.9 1481.67
    93.8 1477.91     102 1475.14     130 1461.85     142  1457.8     154 1454.93
     167 1454.58   175.8 1451.72   206.5 1447.02   229.3 1444.86   256.6 1443.97
   272.2 1441.78   286.9 1441.52   294.1 1439.12     302 1438.91   308.1 1439.14
  318.46 1441.53   324.8 1442.94   344.4 1445.31   368.6 1446.12   381.7 1448.08
   390.5 1450.12   412.4 1456.88   426.1 1464.45   451.8 1477.26   472.5 1485.75
#Mann= 5 ,-1,0
       0      .1       0      40     .05       0     140      .1       0
   286.9    .045       0  318.46      .1       0
Bank Sta=286.9,318.46
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,63383   ,469.3,480.8,481.8
XS GIS Cut Line= 2
2164646.94385934686714.0337528472164263.09662461686460.219233351
#Sta/Elev= 30
       0 1507.16    36.9 1500.94    60.9 1495.23    75.3 1489.99    94.4 1481.44
   108.8 1478.08     128 1470.02   181.6 1453.78   216.2 1440.33   223.9 1439.89
   247.9 1441.75   267.1 1440.73   281.5 1441.54   291.6 1440.54   306.1  1441.4
     315  1440.7   320.6 1438.88   327.9 1438.38     349  1438.5   351.9 1439.36
  353.64 1440.57   358.2 1446.25   363.4 1450.91   377.9 1456.23   407.7 1465.87
   430.1 1474.86   434.9 1477.51   439.7 1482.05   443.9  1484.5   460.2 1491.86
#Mann= 3 ,-1,0
       0      .1       0     315    .045       0  353.64      .1       0
Bank Sta=315,353.64
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,62902   ,333.3,359.3,371.7
XS GIS Cut Line= 3
2164845.78861702686407.1047680292164570.73274353686109.298138932
2164404.32287177686131.344368142
#Sta/Elev= 30
       0 1499.03     8.1 1496.98    13.8 1494.84    35.3 1489.26    49.5 1485.88
    78.9 1479.99   111.5 1470.83   133.3 1465.69   149.8 1460.82   180.8 1450.57
     195 1446.99   209.5 1445.52   238.2 1444.97   255.9 1440.89   302.6 1442.32
   307.5 1440.81   314.8 1438.92   339.4 1438.46     345 1438.79  350.78 1441.29
   378.3 1456.08   397.4 1464.56     416 1470.73   456.4  1478.7   464.5 1480.98
   478.8 1485.98   496.7 1491.01   533.1 1499.39   549.2  1502.2   573.3 1504.94
#Mann= 4 ,-1,0
       0      .1       0   307.5    .045       0  350.78      .1       0
  573.26     .05       0
Bank Sta=307.5,350.78
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,62542   ,427.2,462.4,485.3
XS GIS Cut Line= 3
2164882.35461944686407.4181416922164879.84161944686175.142997585
2164863.24773732685779.133877286
#Sta/Elev= 30
       0 1503.95    26.2 1500.71    62.2 1490.47    78.2 1488.21   114.2 1484.64
   134.2 1481.14   170.2 1472.81   186.1 1468.45   206.3  1462.5   242.3 1450.38
   262.3 1446.59   274.3 1445.16   286.3 1444.68     353 1447.13   366.4 1445.71
   391.4 1441.37   434.4 1440.41   446.4 1441.48     449 1440.81   454.4 1438.22
   474.5 1437.44   482.5 1437.61  490.24  1440.8   498.5 1449.18     522 1458.17
   542.5 1464.77   558.5 1468.87   602.7 1482.42   610.4 1484.42   628.6 1487.72
#Mann= 3 ,-1,0
       0      .1       0     449    .045       0  490.24      .1       0
Bank Sta=449,490.24
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,62080   ,536.9,538,541.2
XS GIS Cut Line= 3
2164909.31312133686420.6598917782164949.50727186686339.471680249
2165335.81399172686166.728874871
#Sta/Elev= 30
       0 1503.99    21.7 1499.21    31.6 1498.16    35.1 1497.04    42.5 1492.76
    49.5  1490.5    58.5 1488.22    78.6 1484.84    90.6 1481.58    97.4 1478.48
   141.7 1454.22   154.9 1448.21   164.8 1444.98   185.5 1442.76   203.1 1439.77
   213.8 1439.95   233.7 1442.41   246.9 1441.58   255.6 1439.51   268.8 1439.59
   273.2 1437.49   277.5 1436.98   295.1 1437.52  299.07 1439.56   303.8 1444.08
   309.3 1447.61   360.8 1457.81   430.9 1475.57   470.3 1490.28   513.8  1504.5
#Mann= 3 ,-1,0
       0      .1       0   268.8    .045       0  299.07      .1       0
Bank Sta=268.8,299.07
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,61542   ,568.6,570.6,568
XS GIS Cut Line= 2
2164989.94462013686838.2878817712165517.99011305686682.955751811
#Sta/Elev= 30
       0  1512.7    10.7 1509.84    27.3 1500.88      44 1494.63    56.5 1487.69
      69 1481.87   106.6 1468.53   114.9 1464.41   127.4 1459.57   144.4 1451.31
   154.1 1448.16   160.6 1444.33  165.41 1439.71   170.2  1437.1   184.8 1436.41
   194.1 1437.21   199.2 1439.74   205.7 1441.01     215 1440.19   235.8 1441.15
   248.3 1440.93   279.8 1443.54   302.5 1443.73   318.4 1445.77   335.9 1449.54
   381.7 1462.84   456.8 1489.82   494.3 1499.69   518.2 1509.17   550.4 1524.51
#Mann= 3 ,-1,0
       0      .1       0  165.41    .045       0   199.2      .1       0
Bank Sta=165.41,199.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,60971   ,395.2,384.1,369
XS GIS Cut Line= 3
2165061.10111995687284.8776208162165281.64125026687332.316364346
2165674.03125026687213.426864519
#Sta/Elev= 30
       0 1513.04    44.1 1507.67    68.6 1502.47    80.9 1498.66   121.8 1480.91
   140.9 1474.14   162.7  1468.9   179.1 1466.27   199.5 1461.75   265.4 1444.12
   278.4 1441.81   287.9 1439.21   307.1 1439.77   313.5 1438.94   320.2  1436.6
   328.5 1435.89   345.3 1436.38   350.6 1438.97   355.2 1441.19   378.7 1440.99
   390.5  1442.8   420.5 1444.87     445 1449.07   462.3 1453.26   512.4 1468.63
   544.5 1477.48   586.2 1485.58   608.6 1492.05   621.1 1496.86   635.6 1499.73
#Mann= 3 ,-1,0
       0      .1       0   313.5    .045       0   350.6      .1       0
Bank Sta=313.5,350.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,60587   ,449.1,425.9,393.1
XS GIS Cut Line= 3
2165316.68124681687799.6226256472165455.73375112687738.943243703
2165719.99262703687443.304864174
#Sta/Elev= 30
       0 1490.15      30 1478.08    38.7 1475.18    86.5 1461.03   108.6 1456.52
   130.4 1455.25   158.4 1452.33     197 1446.73   223.8 1443.99   242.4 1439.88
     256 1439.72   286.4  1441.2   298.9 1440.63  302.92 1439.11   309.1 1436.07
   320.4 1435.81   332.4 1436.15   341.9  1439.2   344.4 1439.81   351.6 1439.66
   356.4 1440.16     374 1444.07   392.5 1445.25   405.4 1447.04   436.6 1454.55
   454.5 1459.89   476.2 1465.42   500.5 1469.72   527.2  1473.6   548.2 1478.35
#Mann= 4 ,-1,0
       0     .05       0  211.72      .1       0  302.92    .045       0
   341.9      .1       0
Bank Sta=302.92,341.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,60161   ,407.7,408,400.6
XS GIS Cut Line= 2
2166017.95241089687871.8161478992165761.09497373687464.649812265
#Sta/Elev= 30
       0 1479.08     7.8 1476.82    18.3 1474.79    33.3 1470.03    78.8 1458.03
   101.8 1453.23   126.1 1449.36   153.3 1446.36   191.7 1440.04     197 1439.73
   209.1 1440.38  214.67 1438.28   220.7  1435.9   234.9 1435.56   239.6 1436.37
   244.3  1438.3   253.8 1439.53   267.1 1439.49   273.2 1440.34   296.1 1439.75
   310.5  1441.5   334.2 1442.05   342.5 1443.15   353.1 1446.17   395.7 1463.79
   409.8 1468.34   419.3 1470.48   438.2 1472.74   461.9 1476.69   481.4 1480.75
#Mann= 4 ,-1,0
       0     .05       0      70      .1       0  214.67    .045       0
   244.3      .1       0
Bank Sta=214.67,244.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,59754   ,554.3,629.6,663.7
XS GIS Cut Line= 4
 2166301.9855855687702.2541549792166351.21516726687606.778602491
2166067.77212081 687299.466667922165991.69003992 687129.40084005
#Sta/Elev= 30
       0 1460.95      41 1458.97   107.4 1457.55   142.2 1451.83   164.5 1446.96
   169.5 1445.54   176.8 1439.69   181.5 1437.67   202.1 1437.47   218.4 1438.88
   274.9 1440.18   283.4 1440.13  289.61 1437.99   294.7  1435.6   305.5  1435.3
   317.3 1435.74   324.3 1438.07   338.1 1439.38   414.3 1438.51   430.5 1442.73
   450.4 1446.51   475.9  1449.6     528 1457.59   544.1 1459.21   554.3  1461.4
   571.8 1463.33   602.9 1473.94   633.2 1479.65   685.7 1486.66711.7966    1492
#Mann= 4 ,-1,0
       0     .05       0  177.42      .1       0  289.61    .045       0
   324.3      .1       0
Bank Sta=289.61,324.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1
